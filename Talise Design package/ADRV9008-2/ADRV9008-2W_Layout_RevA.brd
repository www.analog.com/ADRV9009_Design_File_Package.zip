# Allegro board ADRV9008-2W_Layout_RevA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD1P3_DIG: length 105.7
  TOP w0.203: R716.1 64.36,10.34 P904.1
  TOP w0.254: v1(37.24,35.68) U101.L9 v1(37.24,34.88) U101.L8 v1(37.24,34.08)
  TOP w0.508: R923.2 80.14,6.39 78.97,5.22 71.64,5.22 v2(70.65,6.21) v2(69.76,6.21) v2(68.87,6.21) v2(67.98,6.21) v2(67.98,6.97) v2(68.87,6.97) v2(69.76,6.97) v2(70.65,6.97)
  TOP w1.27: P904.1 68.02,9.57 C951.1
  L5_SIG w0.508: 64.04,9.57 P904.1 ; P904.1 65.12,8.49 ; P904.1 66.2,9.57 ; P904.1 65.12,10.65
  L5_SIG w1.905: 63.57,9.51 62.86,10.22 55.54,10.22 54.11,11.65 54.11,19.71 v2(52.42,21.4) v2(52.42,22.31) v2(53.47,22.31)
  L8_SIG w0.508: 64.04,9.57 P904.1 ; P904.1 65.12,8.49 ; P904.1 66.2,9.57 ; P904.1 65.12,10.65
  L12_PWR w0.635: v1(37.24,34.88) v1(37.24,35.68)
  L12_PWR w1.016: v1(37.24,34.88) v1(37.24,34.08) 38.25,33.07 40.27,33.07
  L12_PWR w1.27: 48.9,27.61 48.9,29.51 46.23,32.18 41.16,32.18 40.27,33.07
  L12_PWR w1.905: 48.9,27.61 50.17,26.34 50.17,24.8 52.66,22.31 ; 52.66,22.31 v2(53.47,22.31) v2(53.47,21.42) 53.46,21.4 v2(52.42,21.4) v2(52.42,22.31) 52.66,22.31
  BOTTOM w0.305: 37.24,34.46 v1(37.24,34.88) v1(37.24,35.68) 37.1,35.54 C643.1 ; 37.24,34.46 v1(37.24,34.08) ; 37.24,34.46 C642.1
  BOTTOM w0.508: P904.1 66.2,9.57 ; P904.1 65.12,10.65 ; P904.1 64.04,9.57 ; P904.1 65.12,8.49
  BOTTOM w0.762: P904.1 64.99,9.44 C640.1
VDD_IF_LDO: length 2.9
  TOP w0.254: 58.1,3.62 58.1,2.46 57.63,1.99 U902.5
  TOP w0.305: U902.7 56.66,3.36
VDD_INTERFACE: length 233.6
  TOP w0.203: v2(100.09,39.42) 100.09,39.42 C425.1 ; R102.1 92.59,45.57 94.19,45.57 v2(94.81,44.94) ; v2(117.49,47.87) 117.21,48.14 U402.8
  TOP w0.254: U101.M12 v1(38.04,38.08)
  TOP w0.305: 51.01,4.35 51.41,3.94 U902.1 ; v1(137.83,40.26) 137.92,40.34 R833.1 R832.1 ; U902.2 51.35,3.29 51.03,3.61 ; R718.1 55.25,13.39 v2(56.78,11.86) ; R939.2 50.3,3.95 ; U404.4 120.01,22.36 120.51,21.87 120.51,21.54 120.98,21.06 U404.1 122.11,21.06 v2(122.3,20.87) ; v2(117.49,47.87) 118.19,47.87 118.84,48.52 U403.1 ; v2(122.74,53.6) U403.8 ; R106.1 v2(94.81,44.94) ; R104.1 93.34,36.75 98.32,36.75 100.09,38.52 v2(100.09,39.42) 100.09,39.99 R108.1
  TOP w0.394: v1(132.75,12.32) 132.75,12.32 R111.1 ; P701.1 v2(60.2,66.02)
  TOP w0.508: P907.1 46.98,3.71 ; P907.1 46.98,1.55 ; P907.1 45.9,2.63 ; P907.1 48.06,2.63
  TOP w0.762: v2(131.48,9.78) 131.45,9.75 R938.2
  L3_PWR w0.508: v2(100.09,39.42) 100.09,41.5 100.21,41.62 100.21,42.15 99.83,42.52 99.47,42.52 97.05,44.94 97.05,45.23 96.52,45.76 95.64,45.76 v2(94.81,44.94)
  L3_PWR w0.635: 122.94,16.17 122.94,20.23 v2(122.3,20.87) ; 122.94,16.17 124.59,16.17 127.19,13.57 131.5,13.57 v1(132.75,12.32) 132.75,11.05 v2(131.48,9.78) ; 122.94,16.17 119.83,16.17 118.91,15.26 95.23,15.26 93.51,16.97 85.83,16.97 85.37,17.42 80.03,17.42 v2(78.75,18.71) 77.87,18.71 v2(77.86,18.72) v2(77.1,18.72)
  L12_PWR w0.203: 56.78,9.95 v2(56.78,11.86)
  L12_PWR w0.508: v2(122.74,53.6) 123.83,52.5 123.83,48.69 125.36,47.16 125.36,40.18 ; 115.2,40.43 115.2,46.78 116.28,47.87 v2(117.49,47.87) ; 46.98,1.55 P907.1 ; P907.1 45.9,2.63 ; P907.1 48.06,2.63 ; P907.1 46.98,3.71
  L12_PWR w0.762: v1(38.04,38.08) 41.47,38.08 43.63,40.24 45.53,40.24 49.15,43.85 75.2,43.85 76.08,42.97 ; v2(60.2,66.02) 64.26,61.95 64.26,61.13 66.04,59.35 66.04,56.43 66.93,55.54 68.2,55.54 71.38,52.36 71.38,48.69 72.65,47.42 76.97,47.42 78.5,45.89 78.5,45
  BOTTOM w0.305: v1(38.04,38.08) 38.57,38.61 R110.1
  BOTTOM w0.394: v2(121.54,26.84) 123.19,25.19 123.19,22.65 122.3,21.76 v2(122.3,20.87) 122.07,20.63 C421.2 ; P801.K40 v2(131.48,9.78) ; C423.2 122.81,53.53 v2(122.74,53.6) ; P801.J39 v1(132.75,12.32)
  BOTTOM w0.762: 46.45,3.16 46.45,3.14 46.47,3.14 ; 46.45,3.16 C934.2 ; 46.45,3.16 46.47,3.14 ; 46.47,3.14 P907.1
VDDA1P3_ANLG: length 67.3
  TOP w0.305: R726.1 v2(44.45,16.41)
  TOP w0.394: R916.2 83.03,20.04
  TOP w0.508: 57.79,14.77 TP601.1 ; TP601.1 58.8,15.79 ; TP601.1 59.82,14.77 ; TP601.1 58.8,13.76 ; P903.1 77.6,15.46 82.18,20.04 83.03,20.04 ; P903.1 65.06,14.38 ; P903.1 63.98,15.46 ; P903.1 65.06,16.54
  TOP w0.762: C950.1 68.14,15.29 65.23,15.29 P903.1 64.35,16.17 C602.1
  L8_SIG w0.508: 58.8,13.76 TP601.1 ; TP601.1 58.8,15.79 ; TP601.1 57.79,14.77 ; TP601.1 59.82,14.77 ; 65.06,14.38 P903.1 ; P903.1 66.14,15.46 ; P903.1 63.98,15.46 ; P903.1 65.06,16.54
  BOTTOM w0.394: v6(28.71,14.01) 28.7,14.02 R604.1 ; R605.1 v2(45.85,18.33)
  BOTTOM w0.508: v2(41.53,15.15) v2(41.53,15.91) R601.1 ; 63.98,15.46 P903.1 ; P903.1 66.14,15.46 ; P903.1 65.06,14.38 ; P903.1 65.06,16.54 ; TP601.1 58.8,15.79 ; TP601.1 59.82,14.77 ; TP601.1 57.79,14.77 ; TP601.1 58.8,13.76 ; R607.1 7.5,30.39 v2(7.5,29.5) ; R609.1 v2(7.24,19.6)
  BOTTOM w0.762: R610.1 20.84,57.44 21.59,57.44 ; R606.1 22.23,16.49 ; 21.59,57.44 v2(21.6,57.44) 21.6,57.44 21.59,57.44 ; 59.73,16.97 59.73,17.6 60.07,17.95 ; 6.99,48.93 R608.1
  BOTTOM w1.016: 19.59,61.66 19.59,61.66 v8(19.64,61.71) ; 19.59,61.66 v8(18.69,60.76) ; 19.59,61.66 E602.1 ; v8(9.65,48.93) 8.38,48.93 ; 8.38,48.93 8.38,48.94 v8(8.32,48.94) ; 8.38,48.93 6.99,48.93
  BOTTOM w1.143: v2(22.23,15.53) 22.23,15.61 22.25,15.62 22.25,16.48 22.23,16.49
  vias: v2(49.66,18.33) v2(50.33,18.33) v2(61.35,15.03) v2(61.35,14.27) v2(62.24,15.03) v2(62.24,14.27) v2(63.13,15.03) v2(63.13,14.27)
VDDA1P3_AUX_SYNTH: length 32.2
  TOP w0.254: U101.G8 v5(34.04,34.88)
  L12_PWR w0.279: v5(34.04,34.88) 33.64,35.27 33.64,35.8 33.63,35.82 33.63,35.84 33.4,36.07 33.38,36.07 33.36,36.08 33.07,36.08 32.84,36.31 32.84,36.64 32.61,36.87 30.99,36.87 29.85,38.01 29.85,38.9 29.47,39.28 29.4,39.28 29.4,39.28 29.07,39.28 28.84,39.51 28.84,39.79 28.83,39.8 28.83,39.84 28.39,40.28 v6(28.08,40.28)
  L12_PWR w0.508: TP612.1 22.35,53.76 v6(28.08,40.28)
  BOTTOM w0.305: C633.1 28.07,40.29
  BOTTOM w0.508: C631.1 27.94,40.87 ; 27.94,40.87 27.94,40.42 v6(28.08,40.28) ; 27.94,40.87 28,40.81 C633.1
  BOTTOM w0.762: 20.65,55.18 20.65,56.12 20.7,56.17 20.7,56.19 ; 20.65,55.18 20.65,54.85 TP612.1 ; 20.65,55.18 20.69,56.17 20.7,56.18 20.7,56.19 ; 20.7,56.19 R610.2
VDDA1P3_AUX_VCO_LDO: length 28.3
  TOP w0.254: v5(30.04,35.68) U101.C10
  L12_PWR w0.508: v6(19.24,30.27) 22.53,30.27 25.1,32.84 25.82,32.84 26.81,33.83 v6(27.19,33.83)
  BOTTOM w0.203: 30.06,35.7 v5(30.04,35.68) ; 13.97,30.39 13.98,30.41 C623.1 ; C622.1 29.5,35.7
  BOTTOM w0.394: v6(27.19,33.83) 27.64,34.28 27.64,35.07 28.27,35.7 30.06,35.7
  BOTTOM w0.508: 11.33,30.39 C621.1 ; 11.33,30.39 19.12,30.39 v6(19.24,30.27) ; 11.33,30.39 10.16,30.39 9.65,30.9 8.64,30.9 ; 8.64,30.9 TP609.1 8.63,31.97 R607.2 8.64,30.41 8.64,30.9
VDDA1P3_BB: length 21.1
  TOP w0.254: v1(31.64,31.68) U101.E5
  BOTTOM w0.203: C604.1 31.5,31.82 v1(31.64,31.68)
  BOTTOM w0.508: v1(31.64,31.68) 31.25,31.29 C605.1 31.38,30.9 31.94,30.33 31.94,29.44 32.7,28.68 32.7,28.25 33.78,27.18 36.36,27.18 37.15,26.39 37.34,26.39 37.46,26.28 37.84,26.28 38.69,25.42 38.69,25.28 39.11,24.86 39.25,24.86 39.81,24.3 39.87,24.3 40.62,23.54 40.62,22.66 TP603.1 41.4,19.76 C603.1 41.4,19.69 41.4,18.06 R601.2
VDDA1P3_CLOCK_SYNTH: length 21.2
  TOP w0.254: v5(34.04,31.68) U101.G5
  L12_PWR w0.394: TP607.1 45.85,22.56 43.86,24.55 42.67,24.55 41,26.23 39.13,26.23 38.83,25.93 37.87,25.93 36.89,26.91 36.89,29.46 36.21,30.14 35.69,30.14 34.15,31.68 v5(34.04,31.68)
  BOTTOM w0.394: R605.2 TP607.1
  BOTTOM w0.508: C617.1 33.98,31.62 v5(34.04,31.68) 33.97,31.74 C616.1
VDDA1P3_CLOCK_VCO_LDO: length 17.2
  TOP w0.254: v1(38.84,28.48) U101.N1
  BOTTOM w0.203: v1(38.84,28.48) 38.67,28.65 C611.1
  BOTTOM w0.508: R603.2 50.04,20.49
  BOTTOM w0.635: C610.1 40.8,27.82 40.25,28.37 C612.1 38.94,28.37 v1(38.84,28.48)
  BOTTOM w1.016: 50.04,20.49 TP605.1 47.5,24.42 47.5,25.69 45.21,27.98 42.42,27.98 42.26,27.82 C610.1
VDDA1P3_DES: length 36.5
  TOP w0.254: v1(39.64,34.88) U101.P9 v1(39.64,35.68) ; v1(38.84,35.68) U101.N9
  BOTTOM w0.203: C638.1 41.02,35.35
  BOTTOM w0.394: v1(39.64,34.88) v1(39.64,35.68) v1(38.84,35.68)
  BOTTOM w0.508: 60.07,21.37 60.07,22.65 59.98,22.73 ; 59.73,25.23 59.73,26.94 55,31.67 52.71,31.67 48.95,35.43 41.87,35.43 41.79,35.35 39.8,35.35 39.71,35.43 39.64,35.35 ; 60.07,19.22 R611.2
  BOTTOM w0.762: 59.73,25.23 59.98,24.97 C637.1 59.98,21.46 60.07,21.37 TP614.1 60.07,19.22
VDDA1P3_RF_LO: length 16.4
  TOP w0.254: v1(30.04,34.08) U101.C8
  L12_PWR w0.635: 28.82,35.46 29.37,34.7 29.99,34.08 v1(30.04,34.08)
  L12_PWR w0.762: v6(17.27,39.69) v6(17.27,38.98) v6(17.27,38.27) 21.96,38.27 25.75,36.46 28.82,35.46
  BOTTOM w0.508: C627.1 29.97,34.01 v1(30.04,34.08)
VDDA1P3_RF_SYNTH: length 35.5
  TOP w0.254: v5(34.04,34.08) U101.G7
  L12_PWR w0.203: v7(25.53,60.49) v7(25.02,60.49)
  L12_PWR w0.279: v5(34.04,34.08) 34.46,34.5 35.01,34.5 35.26,34.75 35.26,36.65 34.22,37.68 33.87,37.68 33.78,37.78 33.13,37.78 31.37,39.54 30.36,39.54 29.34,40.55 29.34,41.93 28.74,42.53 28.74,43.64 29.09,43.98 29.09,45.11 28.95,45.24 28.95,50.58 29.36,50.99 29.36,54.63 25.53,58.46 v7(25.53,60.49)
  BOTTOM w0.203: v7(25.53,60.49) v7(25.02,60.49)
  BOTTOM w0.508: v5(34.04,34.08) 34.04,34.07 C609.1
VDDA1P3_RF_VCO_LDO: length 31.3
  TOP w0.254: v1(30.04,32.48) U101.C6 ; U101.C5 v3(30.04,31.68)
  L3_PWR w0.508: v1(30.04,32.48) v3(30.04,31.68)
  L12_PWR w0.508: v6(25.66,31.29) 22.01,27.63 v6(19.18,27.63)
  BOTTOM w0.305: v1(30.04,32.48) 30.03,32.49 C629.1 29.09,32.61 ; C628.1 15.15,26.36 15.13,26.37
  BOTTOM w0.394: 29.09,32.61 C630.1 27.68,32.61 27.56,32.49 26.86,32.49 v6(25.66,31.29)
  BOTTOM w0.508: R609.2 9.53,19.6 10.37,18.75 11.09,18.75 12.19,19.85 TP611.1 12.7,20.36 13.78,21.44 13.78,25.02 16.39,27.63 v6(19.18,27.63)
VDDA1P3_RX_RF: length 8.4
  TOP w0.254: U101.B1 v1(29.24,28.48)
  L12_PWR w0.394: v6(28.71,23.03) 28.1,23.64 28.1,24.2 28.71,24.81 v7(28.71,26.06)
  BOTTOM w0.305: C615.1 29.5,28.74 v1(29.24,28.48) 29.23,28.47
  BOTTOM w0.394: R612.2 28.7,23.03 v6(28.71,23.03) ; 28.71,26.71 C613.1 ; 28.71,26.71 v7(28.71,26.06) ; 28.71,26.71 28.71,27.52 28.91,27.71 28.91,28.14 29.23,28.47
  BOTTOM w0.508: C614.1 28.92,27.73 28.91,27.71
VDDA1P3_RX_TX: length 11.2
  TOP w0.254: v1(30.04,30.88) U101.C3
  BOTTOM w0.394: v1(30.04,30.88) 30.04,30.2 30.29,29.95 C620.1 ; 24.25,18.67 24.25,18.68 C618.1
  BOTTOM w0.762: R606.2 23.28,17.7
  BOTTOM w1.143: v6(26.93,25.95) TP608.1 26.4,22.79 24.25,18.67 23.28,17.7
VDDA1P3_SER: length 30.1
  TOP w0.254: U101.N8 v1(38.84,34.08) U101.P8 v1(39.64,34.08)
  BOTTOM w0.203: C634.1 40.2,33.81 40.2,33.8
  BOTTOM w0.394: C635.1 40.2,32.86 40.2,32.89
  BOTTOM w0.508: v1(38.84,34.08) v1(39.64,34.08) 39.93,34.08 40.2,33.8 40.2,32.89 40.28,32.81 ; 40.28,32.81 C635.1 ; 40.28,32.81 40.92,32.17 46.23,32.17 48.64,29.76 50.69,29.76 51.36,29.09 53.9,29.09 56.52,26.47 56.52,23.11 56.52,23.1 TP613.1
  BOTTOM w1.016: E611.2 TP613.1
VDDA1P8_BB: length 67.4
  TOP w0.254: v5(32.44,30.88) U101.E4
  TOP w0.394: R722.1 v2(49.47,17.18)
  L5_SIG w0.114: v2(49.47,17.18) 49.47,16.49 43.69,10.71 41.02,10.71 40.64,11.09 34.67,11.09 33.91,10.33 31.63,10.33 31.37,10.58 29.59,10.58 27.82,8.8 26.55,8.8 TP903.1
  L10_SIG w0.279: 30.94,28.8 31.24,29.1 31.24,30.24 31.49,30.48 32.04,30.48 v5(32.44,30.88)
  L10_SIG w0.305: 30.94,28.8 30.5,28.8
  L10_SIG w0.394: 29.83,27.62 29.83,28.12 30.5,28.8
  L10_SIG w0.508: 29.83,27.62 27.94,25.73 27.94,23.79 28.44,23.29 28.44,20.1 26.86,18.52 26.86,17.12 25.02,15.28 25.02,8.04
  L10_SIG w0.762: TP903.1 25.02,7.28 25.02,8.04
  BOTTOM w0.305: v5(32.44,30.88) 32.51,30.95 C944.1 ; 25.61,5.75 R942.2
  BOTTOM w0.508: C945.1 32.58,30.73 v5(32.44,30.88)
  BOTTOM w1.016: 24.35,6.43 C943.1 ; 24.35,6.43 TP903.1 24.26,8.55 C942.1 ; 24.35,6.43 25.02,5.75 25.61,5.75
VDDA1P8_TX: length 61.3
  TOP w0.203: U101.E12 v3(31.64,38.08)
  TOP w0.279: C947.1 v4(26.48,41.06)
  TOP w0.305: C948.1 26.3,40.88 v4(26.48,41.06)
  TOP w0.394: v4(47.39,17.17) R724.1
  TOP w0.508: TP901.1 101.22,3.72 ; TP901.1 99.19,3.72 ; TP901.1 100.21,2.71 ; TP901.1 100.21,4.74 ; L316.1 32.18,25.43 C316.1 32.18,24.14 v2(32.17,24.13) ; L307.2 32.15,42.72 C307.1 32.15,44.01 v2(32.13,44.02) ; v2(37.54,24.13) 37.53,24.14 C315.1 37.53,25.43 L315.2 ; L308.1 37.49,42.72 C308.1 37.49,44.01 v2(37.5,44.02)
  L3_PWR w0.203: 30.72,38.46 30.46,38.72 30.46,39.03 30.47,39.04 30.45,39.06 30.45,39.25 30.67,39.25 30.68,39.26 31,39.26 31.26,39 31.26,38.72 31.64,38.34 v3(31.64,38.08) 31.38,38.08 31,38.46 30.72,38.46
  L3_PWR w0.305: v2(32.13,44.02) 32.43,43.73 37.21,43.73 v2(37.5,44.02)
  L3_PWR w0.394: v2(37.54,24.13) 37.12,24.55 32.59,24.55 v2(32.17,24.13) ; 46.99,16.42 46.99,16.78 v4(47.39,17.17)
  L3_PWR w0.508: 99.19,3.72 TP901.1 ; TP901.1 101.22,3.72 ; TP901.1 100.21,2.71 ; TP901.1 100.21,4.74 ; 30.45,39.25 28.64,41.06 v4(26.48,41.06)
  L3_PWR w0.762: 31.37,55.28 31.41,55.25 31.53,55.25 33.35,53.43 33.35,52.64 34.14,51.85 34.62,51.85 36.37,50.1 36.42,50.1 36.91,49.61 36.91,48.91 36.42,48.42 36.32,48.42 34.84,46.94 34.84,43.73 ; 34.81,24.55 34.81,22.64 37.67,19.78 38.07,19.78 38.33,19.51
  vias: v2(101.6,4.74) v2(101.6,2.71) v2(101.86,3.72)
VDDA_1P8: length 113.1
  TOP w0.508: P906.1 106.56,5.82 ; P906.1 106.56,3.66 ; P906.1 107.64,4.74 ; P906.1 105.48,4.74 ; R931.2 102.34,6.62 v2(103.38,5.58) v2(104.14,5.58) v2(104.9,5.58)
  BOTTOM w0.305: C941.2 107.7,3.6 P906.1 105.54,3.72 C940.2 ; 27.05,5.75 R942.1
  BOTTOM w0.508: 106.56,3.66 P906.1 ; P906.1 107.64,4.74 ; P906.1 105.48,4.74 ; P906.1 106.56,5.82
  BOTTOM w1.016: 27.05,5.75 27.94,5.75 28.7,6.52 28.7,11.09 30.23,12.61 34.67,12.61 38.48,8.8 39.88,8.8 42.42,6.26 54.23,6.26 58.04,2.45 59.82,2.45 61.09,1.18 102.49,1.18 104.14,2.83
VDDA_3P3: length 141.4
  TOP w0.254: U101.C12 v3(30.04,38.08)
  TOP w0.394: R720.1 v4(51.56,17.18) ; v1(133.42,62.28) R848.1
  TOP w0.508: R927.2 98.73,20.17 99.61,19.29 v2(101.51,19.29) v2(102.27,19.29) v2(103.04,19.29) 103.04,17.69 R935.1
  L3_PWR w0.203: v3(30.04,38.08) 30.29,38.08 30.67,37.69 30.96,37.69 31.22,37.43 31.22,37.12 31.21,37.11 31.21,36.89 31.02,36.89 31.01,36.9 31,36.89 30.68,36.89 30.42,37.16 30.42,37.44 30.04,37.82 v3(30.04,38.08)
  L3_PWR w0.508: v2(52.2,57.7) 51.82,57.32 49.15,57.32 47.75,58.71 45.72,58.71 ; 45.72,58.71 43.44,58.71 v2(41.53,60.62) ; 45.72,58.71 45.72,56.3 ; 45.72,58.71 45.72,59.86 44.33,61.25 v2(44.33,62.14) ; P905.1 104.45,21.42 ; P905.1 103.37,20.34 ; P905.1 103.37,22.5 ; P905.1 102.29,21.42 ; 31.21,36.89 31.36,36.74 31.88,36.74 32.51,37.38 32.51,38.14 34.04,39.66 35.71,39.66
  L10_SIG w0.203: 59.06,10.71 57.02,12.75 56,12.75 v4(51.56,17.18)
  L12_PWR w0.394: v1(133.42,62.28) 134.87,62.28 139.76,57.39 139.76,54.48 140.99,53.25 140.99,32.06 138.36,29.43 136.31,29.43 134.63,27.75 134.63,27.31 134.27,26.96 133.84,26.96 129.57,22.69 122.27,22.69 120.53,24.43 115.07,24.43 114.46,23.82 111.28,23.82 106.76,19.29 v2(103.04,19.29) v2(102.27,19.29) v2(101.51,19.29)
  BOTTOM w0.305: R119.1 v2(41.53,60.62) ; C135.1 v2(44.33,62.14) ; R120.1 52.39,57.89 v2(52.2,57.7)
  BOTTOM w0.508: 102.29,21.42 P905.1 ; P905.1 104.45,21.42 ; P905.1 103.37,20.34 ; P905.1 103.37,22.5 ; 44.33,61.32 v2(44.33,62.14)
  vias: v2(57.41,8.68) v2(58.43,8.68) v2(58.47,7.41) v2(58.94,8.05) v2(59.45,8.68) v2(59.45,7.41)
1P3_BUCK_OUT: length 25.4
  L8_SIG w0.394: v2(85.18,21.02) 84.4,20.24 77.23,20.24 75.41,18.42 75.41,7.4 v2(76.11,6.69) v2(76.87,6.69) v2(77.64,6.69)
  BOTTOM w0.394: v2(85.18,21.02) 85.59,20.61 R905.1
3P3V_CLK1: length 38.3
  TOP w0.203: C440.2 107.12,66.77 v2(107.63,66.77) ; U404.6 119.82,20.88 v2(119.82,20.13)
  TOP w0.305: U403.14 118.84,55.23 118.53,55.54 v2(118.11,55.54) 117.74,55.17 C424.2
  TOP w0.394: v2(87.54,65.06) 87.38,64.9 87.38,64.86 C438.2 ; v2(85.14,60.63) 85.47,60.3 C418.1 ; v2(88.87,56.77) 88.87,57.43 C427.2 ; C439.2 86.31,64.8 v2(86.04,65.06) ; C433.2 92.97,62.63 v2(93.45,62.63) ; C435.2 91.77,64.8 v2(92.04,65.06) ; v2(86.11,56.73) 86.11,57.39 C426.1 ; C441.2 83.31,57.16 v2(83.2,57.05) ; v2(95.34,56.63) C429.2 ; C437.2 88.77,64.8 v2(89.04,65.06) ; C444.2 v2(83.24,65.13) ; v2(93.44,59.63) 92.84,59.03 C431.2 ; C443.2 85.93,62.84 v2(85.14,63.63) ; v2(85.14,62.14) 85.71,61.57 C442.2 ; C436.2 90.27,64.8 v2(90.54,65.06) ; v2(93.42,61.13) 92.76,60.47 C432.2 ; C430.2 93.07,57.76 v2(93.44,58.13) ; C434.2 93.41,67.17 v2(93.41,66.78) ; C428.2 v2(93.54,54.83)
  BOTTOM w0.203: U401.1 v2(93.54,54.83) ; U401.48 v2(90.54,65.06) ; 94.24,56.63 U401.72 ; 89.04,55.93 U401.10 ; U401.16 86.04,56.73 v2(86.11,56.73) ; U405.5 v2(107.63,66.77) ; U401.66 v2(93.44,59.63) ; 92.04,65.07 U401.51 ; U401.69 v2(93.44,58.13) ; U401.39 v2(86.04,65.06)
  BOTTOM w0.254: v2(92.04,65.06) 92.04,65.07 ; U401.27 v2(85.14,60.63) ; U401.45 v2(89.04,65.06) ; U401.33 v2(85.14,63.63) ; 89.04,55.93 89.04,56.54 88.84,56.75 88.84,56.85 88.87,56.85 v2(88.87,56.77) ; v2(93.42,61.13) 93.42,61.13 93.42,61.13 93.42,61.13 U401.63 ; U401.30 84.98,62.13 85.03,62.08 85.03,62.14 v2(85.14,62.14) ; U401.60 v2(93.45,62.63) ; v2(93.41,66.78) 93.41,66.91 93.54,66.78 U401.54 ; U401.20 83.82,57.13 83.8,57.11 83.72,57.11 83.66,57.05 v2(83.2,57.05) ; U401.36 v2(83.24,65.13) ; U401.42 v2(87.54,65.06) ; v2(95.34,56.63) 94.24,56.63
  BOTTOM w0.394: C422.2 v2(119.82,20.13) ; R440.1 82.98,56.83 v2(83.2,57.05)
  vias: v2(109.99,19.03) v2(109.99,18.27) v2(110.88,19.03) v2(110.88,18.27) v2(111.77,19.03) v2(111.77,18.27)
3P3V_VCXO: length 64.1
  BOTTOM w0.305: C938.2 127.01,62.26 127.01,62.27
  BOTTOM w0.394: Y401.6 Y402.6 v2(111,63.8) C407.2
  BOTTOM w0.508: R408.1 124.35,60.21 124.82,60.69 125.56,61.43 v2(125.56,62.27) v2(126.23,62.27) 127.53,62.27 130.06,59.74 130.06,42.13 126.97,39.04 126.5,39.04 120.53,33.07 118.75,33.07 116.21,30.53 114.18,30.53 111.13,27.48 109.86,27.48 107.97,25.59 103.91,25.59 E906.2
3P3VAUX: length 104.4
  TOP w0.305: R708.2 113.21,20.73 v2(112.97,20.97) ; U702.8 123.44,19.28 125.11,19.28 ; U703.17 U703.16 ; v2(127.68,19.26) 127.66,19.28 126.61,19.28 ; 126.61,19.28 C703.1 ; 126.61,19.28 125.11,19.28 ; U703.10 v2(45.49,9.59) ; 125.11,19.28 C704.1 ; R709.2 v2(113.8,17.83) ; R710.2 v2(113.8,16.05)
  TOP w0.635: v8(51.2,7.67) 51.2,8.94 50.55,9.59 U703.16
  L10_SIG w0.394: v2(45.49,9.59) 46.4,8.68 50.18,8.68 v8(51.2,7.67)
  L10_SIG w0.762: v8(51.2,7.67) 52.84,7.67 57.03,3.48 59.19,3.48 61.6,1.06 105.66,1.06 105.96,0.76 107.15,0.76 107.45,1.06 110.12,1.06 113.8,4.75 v2(113.8,16.05) v2(113.8,17.83) 113.8,20.13 v2(112.97,20.97)
  BOTTOM w0.394: P801.D32 v1(139.1,21.21) ; C701.2 50.22,8.37 50.91,7.67 v8(51.2,7.67) 51.19,7.68 C702.1
ADP5054_VREG: length 20.4
  TOP w0.394: R903.2 87.86,8.29 v2(88.25,8.68) 88.95,9.38 90.64,9.38 91.04,8.98 91.04,8.83 v2(91.07,8.8) 91.4,9.13 91.4,16.32 v2(89.62,18.1)
  BOTTOM w0.203: U901.44 88.75,17.22 89.03,17.5 ; U901.45 89.25,17.28 89.03,17.5 ; 89.03,17.5 v2(89.62,18.1) 89.7,18.17 C902.2
  BOTTOM w0.254: v2(91.07,8.8) 90.75,9.12 U901.13 ; U901.18 v2(88.25,8.68)
AUX_SYNTH_VTUNE: length 49.1
  TOP w0.203: J101.1 56.39,35.98 P104.6
  TOP w0.254: v3(39.64,28.48) U101.P1
  L5_SIG w0.114: v3(39.64,28.48) 39.25,28.86 37.33,28.86 36.58,29.61 36.34,29.61 35.17,30.78 35.17,31.02 34.91,31.28 34.76,31.28 34.5,31.54 34.5,39.05 34.74,39.28 34.74,42.39 36.25,43.91 36.68,43.91 36.98,44.21 36.98,44.64 37.91,45.57 44.42,45.57 44.68,45.31 45.27,45.31 45.85,45.89 51.31,45.89 55.12,42.08 55.12,40.11 P104.6
AUXADC_0: length 64.3
  TOP w0.254: U101.F3 v3(32.44,30.08)
  L8_SIG w0.114: P103.3 79.89,50.97 79.89,49 79.19,48.3 72.35,48.3 68.8,44.74 48.92,44.74 44.74,40.56 43.28,40.56 40.98,38.27 39.8,38.27 39.72,38.35 39.44,38.35 39.24,38.15 39.24,38 38.85,37.61 36.3,37.61 36.1,37.42 36.1,37.14 35.78,36.81 35.5,36.81 35.3,36.62 35.3,35.66 34.98,35.34 34.78,35.34 34.5,35.06 34.5,34.79 34.2,34.49 33.9,34.49 33.65,34.24 33.65,34.01 33.33,33.69 33.15,33.69 32.77,33.32 32.77,33.14 32.1,32.46 32.1,30.41 v3(32.44,30.08)
  BOTTOM w0.203: C131.1 81.09,52.3 P103.3
AUXADC_1: length 66.8
  TOP w0.254: U101.F4 v3(32.44,31.68)
  L7_SIG w0.114: 81.16,49.7 79.95,48.49 64.65,48.49 63.63,47.47 47.69,47.47 46.74,48.43 40.77,48.43 37.47,45.12 36.32,45.12 32.83,41.63 32.83,40.13 32.72,40.01 32.3,40.01 32.2,39.92 31.97,39.69 31.97,39.54 31.78,39.34 31.63,39.34 31.17,38.89 31.17,38.74 30.98,38.54 30.83,38.54 30.48,38.2 30.48,35.52 30.79,35.21 30.98,35.21 31.24,34.95 31.24,33.99 31.5,33.74 31.65,33.74 32.1,33.29 32.1,32.34 32.44,32 v3(32.44,31.68)
  BOTTOM w0.203: 81.16,49.7 81.09,49.63 C132.1
AUXADC_2: length 84.2
  TOP w0.254: v3(32.44,36.48) U101.F11
  L5_SIG w0.114: v3(32.44,36.48) 32.1,36.81 29.23,36.81 25.88,40.16 25.88,45.09 25.08,45.89 25.08,47.92 26.59,49.42 26.59,50.46 25.91,51.14 25.91,55.03 27.56,56.68 28.58,56.68 30.23,58.33 38.1,58.33 39.69,59.92 62.42,59.92 66.04,56.3 74.55,56.3 75.94,54.91 75.94,54.88 76.24,54.58 76.27,54.58 P103.5
  BOTTOM w0.203: C133.1 78.55,52.3 P103.5
AUXADC_3: length 82.2
  TOP w0.203: U101.E11 v3(31.64,37.28)
  L5_SIG w0.114: 78.62,49.7 77.35,50.97 77.35,52.68 76.08,53.95 66.24,53.95 61.03,59.16 39.94,59.16 38.48,57.69 36.23,57.69 35.72,57.19 29.93,57.19 28.82,56.09 27.73,56.09 26.5,54.86 26.5,51.39 27.18,50.71 27.18,49.03 25.78,47.63 25.78,46.18 26.93,45.03 26.93,42.21 27.08,42.05 28.51,40.62 28.51,40.17 28.83,39.85 28.83,39.61 29.15,39.28 29.31,39.28 29.57,39.02 29.57,38.79 29.96,38.41 30.18,38.41 30.5,38.09 30.5,37.94 30.74,37.7 31.22,37.7 v3(31.64,37.28)
  BOTTOM w0.203: 78.62,49.7 78.55,49.63 C134.1
CLK+: length 7.5
  BOTTOM w0.203: C403.2 93.54,50.77 92.72,50.77 ; 92.72,50.77 R406.1 ; 92.72,50.77 92.28,50.77 92.06,50.99 92.06,51.72 92.97,52.62 92.97,55.06 93.04,55.13 U401.2
CLK-: length 8.1
  BOTTOM w0.203: 92.72,50.42 92.13,50.42 91.7,50.85 91.7,51.86 92.61,52.77 92.61,55.06 92.54,55.13 U401.3 ; 92.72,50.42 R406.2 ; 92.72,50.42 93.54,50.42 C405.2
CLK_RESETB: length 109.9
  TOP w0.203: U404.5 119.43,21.71 119.1,22.04 119.1,22.68 119.33,22.92 v2(120.18,22.92)
  L7_SIG w0.114: v2(120.18,22.92) 120.75,22.35 121.29,22.35 121.3,22.35 130.27,22.35 131,23.09 134.02,23.09 134.83,23.9 134.83,23.94 135.44,24.56 135.49,24.56 135.76,24.83 135.76,24.87 136.81,25.92 136.86,25.92 137.1,26.16 137.1,26.21 137.64,26.75 137.69,26.75 138.87,27.94 138.87,28.55 142.25,31.92 142.25,46.91 141.94,47.22 137.82,47.22 137.68,47.07 134.72,47.07 132.09,49.7 127.39,49.7 125.23,51.86 105.79,51.86 105.28,51.35 93.8,51.35 92.59,52.55 86.97,52.55 86.9,52.62 86.87,52.62 83.45,56.03 v2(83.45,56.36)
  BOTTOM w0.203: v2(83.45,56.36) 83.72,56.63 U401.19
  BOTTOM w0.394: v2(83.45,56.36) 82.93,55.84 R440.2
CLK_SYSREF_REQUEST: length 36.4
  TOP w0.203: U403.13 v2(119.49,56.68)
  L7_SIG w0.114: v2(97.73,65.95) 97.73,59.41 100.46,56.68 109.22,56.68 109.6,57.06 117.67,57.06 118.05,56.68 v2(119.49,56.68)
  BOTTOM w0.254: U401.57 95.53,64.13 96.27,64.87 96.65,64.87 v2(97.73,65.95) ; R441.2 97.73,66.59
  BOTTOM w0.394: 97.73,66.59 v2(97.73,65.95)
DIR_CLK+: length 12.7
  L10_SIG w0.091: v2(89.35,51.41) 88.65,51.41 88.42,51.18 88.42,50.06 88.51,49.96 90.84,49.96 91.34,50.47 95.3,50.47 95.63,50.79 v2(95.63,52.09)
  BOTTOM w0.203: v2(89.35,51.41) 89.35,51.28 89.78,50.85 R416.2 ; C402.2 94.88,52.09 v2(95.63,52.09)
DIR_CLK-: length 12.8
  L10_SIG w0.091: v2(87.12,51.41) 87.89,51.41 88.16,51.14 88.16,49.95 88.4,49.71 90.95,49.71 91.45,50.21 95.36,50.21 95.63,49.95 v2(95.63,49.09)
  BOTTOM w0.203: v2(95.63,49.09) 94.88,49.09 94.87,49.08 C404.2 ; R415.2 86.76,50.79 87.12,51.16 v2(87.12,51.41)
EPROM_A0: length 115.9
  TOP w0.203: U703.11 47.52,8.19 v2(46.87,7.54)
  TOP w0.305: R708.1 R711.2 115.77,20.09 116.61,19.25 U702.1 118.85,19.25 v2(119.89,18.21)
  L8_SIG w0.114: v2(46.87,7.54) 48.39,9.06 52.34,9.06 57.67,3.73 83.58,3.73 84.65,4.81 94.18,4.81 102.5,13.13 114.31,13.13 119.39,18.21 v2(119.89,18.21)
  L10_SIG w0.114: v1(141.64,17.4) 139.72,17.4 137.37,15.05 137.37,14.85 136.53,14.02 124.08,14.02 v2(119.89,18.21)
  BOTTOM w0.394: P801.C34 v1(141.64,17.4)
EPROM_A1: length 115.8
  TOP w0.203: v2(48.14,7.54) 48.52,7.92 U703.13
  TOP w0.305: v2(118.85,18.39) 118.64,18.6 U702.2 116.46,18.6 116.11,18.95 R712.2 R709.1
  L8_SIG w0.114: v2(118.85,18.39) 118.85,18.43 119.26,18.84 120.02,18.84 120.46,18.41 120.46,18.01 114.06,11.6 105.8,11.6 99.19,4.99 97.67,4.99 95.7,3.03 57.61,3.03 52.09,8.54 49.14,8.54 v2(48.14,7.54)
  L10_SIG w0.114: v1(140.37,16.13) 137.5,13.25 123.98,13.25 v2(118.85,18.39)
  BOTTOM w0.394: P801.D35 v1(140.37,16.13)
EPROM_A2: length 4.1
  TOP w0.305: U702.3 116.5,17.95 116.07,17.51 115.97,17.51 115.63,17.17 R713.2 R710.1
FMC_CLK_RESETB: length 24.7
  TOP w0.305: v1(140.37,28.83) 138.57,27.03 138.57,24.82 135.57,21.82 129.86,21.82 128.97,22.71 123.77,22.71 122.77,21.71 U404.2
  BOTTOM w0.394: v1(140.37,28.83) P801.D26
FMC_SYSREF_REQUEST: length 46.4
  TOP w0.203: U403.2 v2(119.49,50.59)
  L8_SIG w0.114: v1(140.37,26.29) 141.16,27.08 141.16,30.93 141.16,30.93 141.16,31.4 141.16,31.4 141.16,35.29 142.25,36.37 142.25,42.81 141.18,43.88 141.18,43.92 139.13,45.97 132.77,45.97 129.4,49.35 126.86,49.35 125.84,48.33 121.74,48.33 v2(119.49,50.59)
  BOTTOM w0.394: v1(140.37,26.29) P801.D27
FMCA_SCL: length 107
  TOP w0.203: U703.15 49.52,8.06 v2(50.05,7.54)
  TOP w0.305: v2(121.8,18.33) 122.19,17.95 U702.6
  L8_SIG w0.114: v2(50.05,7.54) 51.57,6.02 53.73,6.02 57.41,2.33 95.37,2.33 95.76,1.94 102.24,1.94 103.63,3.34 107.95,3.34 113.54,8.93 113.54,9.82 120.91,17.19 120.91,17.45 v2(121.8,18.33)
  L10_SIG w0.114: v2(121.8,18.33) 122.31,18.33 122.68,18.71 130.69,18.71 133.87,21.89 141.06,21.89 v1(141.64,22.48)
  BOTTOM w0.394: v1(141.64,22.48) P801.C30
FMCA_SDA: length 110.4
  TOP w0.203: U703.14 v2(49.02,7.54)
  TOP w0.305: U702.5 v2(121.82,17.3)
  L8_SIG w0.114: v2(49.02,7.54) 49.02,6.15 53.6,1.57 95,1.57 95.77,0.8 107.44,0.8 114.68,8.04 114.68,10.07 121.82,17.21 v2(121.82,17.3)
  L10_SIG w0.114: v2(121.82,17.3) 123.98,17.3 125.1,16.18 126.88,16.18 127.52,16.81 137.3,16.81 141.64,21.16 v1(141.64,21.21)
  BOTTOM w0.394: v1(141.64,21.21) P801.C31
FMCA_VADJ: length 13.2
  TOP w0.762: 131.44,6.74 129.45,6.74 TP814.1 ; 131.44,6.74 R938.1 ; 131.44,6.74 131.45,6.73 C932.1
  L12_PWR w0.508: 128.3,6.87 TP814.1 ; TP814.1 129.31,7.89 ; TP814.1 127.28,7.89 ; TP814.1 128.3,8.91
  BOTTOM w0.394: P801.H40 v1(134.02,11.05) ; P801.F40 v1(137.83,9.78) ; P801.E39 v1(139.1,11.05) ; P801.G39 v1(136.56,11.05)
FMCA_VCC_3P3V: length 7.7
  L12_PWR w0.508: TP818.1 128.37,12.21 ; TP818.1 127.36,11.19 ; TP818.1 128.37,10.17 ; TP818.1 129.39,11.19
  BOTTOM w0.394: P801.D38 v1(140.37,12.32) ; P801.D36 v1(140.37,14.86) ; P801.D40 v1(140.37,9.78) ; P801.C39 v1(141.64,11.05)
FMCA_VCC_12P0V: length 5.9
  TOP w0.508: TP819.1 122.31,13.89 ; TP819.1 120.28,13.89 ; TP819.1 121.29,12.87 ; TP819.1 121.29,14.91
  BOTTOM w0.394: P801.C35 v1(141.64,16.13) ; P801.C37 v1(141.64,13.59)
FPGA_REF_CLK+: length 49
  TOP w0.203: v1(140.37,56.77) 140.5,56.77 141.01,56.26 C803.1
  L7_SIG w0.091: v1(140.37,56.77) 140.25,56.77 139.99,57.03 139.99,57.41 132.84,64.56 127.36,64.56 126.22,65.7 110.26,65.7 109.45,64.89 108.33,64.89 v2(108.05,65.17)
  BOTTOM w0.203: v2(108.05,65.17) 107.82,64.94 106.43,64.94 102.03,60.53 99.72,60.53 99.59,60.54 99.25,60.88 98.85,60.88 R420.2
FPGA_REF_CLK-: length 49
  TOP w0.203: C804.1 138.5,56.49 138.78,56.77 v1(139.1,56.77)
  L7_SIG w0.091: v2(108.05,64.36) 108.33,64.63 109.55,64.63 110.37,65.44 126.11,65.44 127.26,64.3 132.74,64.3 139.74,57.3 139.74,56.86 139.65,56.77 v1(139.1,56.77)
  BOTTOM w0.203: v2(108.05,64.36) 107.82,64.58 106.58,64.58 102.17,60.18 99.72,60.18 99.58,60.18 99.25,59.85 R419.2
FPGA_SYSREF+: length 44.5
  TOP w0.203: R818.1 135.06,52.81 134.86,53.01 134.86,54.25 135.13,54.25 135.13,54.66 134.86,54.66 134.86,55.07 v1(135.29,55.5)
  L7_SIG w0.091: v2(99.68,63.79) 99.96,63.51 101.12,63.51 103.25,61.38 129.8,61.38 134.81,56.36 134.81,55.73 135.04,55.5 v1(135.29,55.5)
  BOTTOM w0.203: R424.2 99.15,63.56 99.45,63.56 v2(99.68,63.79)
FPGA_SYSREF-: length 44.5
  TOP w0.203: R819.1 135.58,51.79 134.51,52.86 134.51,55.02 v1(134.02,55.5)
  L7_SIG w0.091: v1(134.02,55.5) 134.33,55.5 134.56,55.73 134.56,56.26 129.69,61.13 103.15,61.13 101.01,63.26 99.96,63.26 v2(99.68,62.98)
  BOTTOM w0.203: v2(99.68,62.98) 99.45,63.21 99.16,63.21 R425.2
FPGA_SYSREF_OUT+: length 46.5
  TOP w0.203: v1(139.1,51.69) 139.64,51.15 R834.1
  L7_SIG w0.091: v2(100.74,58.85) 101.01,58.59 121.41,58.59 122.3,57.7 127,57.7 132.21,52.49 135,52.49 136.31,51.18 138.6,51.18 v1(139.1,51.69)
  BOTTOM w0.203: v2(100.74,58.85) 100.48,58.6 100.16,58.6 99.13,57.57 98.27,57.57 98.01,57.82 R451.1
FPGA_SYSREF_OUT-: length 46.5
  TOP w0.203: R835.1 139.13,50.39 v1(139.1,50.42)
  L7_SIG w0.091: v1(139.1,50.42) 139.29,50.61 139.29,50.74 139.1,50.93 136.21,50.93 134.9,52.24 132.1,52.24 126.9,57.44 122.2,57.44 121.31,58.33 100.98,58.33 v2(100.74,58.09)
  BOTTOM w0.203: v2(100.74,58.09) 100.59,58.24 100.31,58.24 99.28,57.22 98.35,57.22 98.01,56.87 R452.1
GP_INTERRUPT: length 113.9
  TOP w0.254: U101.J5 v3(35.64,32.48)
  TOP w0.394: TP804.1 129.63,47.21 R805.1
  L7_SIG w0.114: TP804.1 127.72,45.4 123,40.68 103.76,40.68 100.4,44.05 86.9,44.05 84.89,42.03 84.89,40.85 84.2,40.17 83.25,40.17 82.34,39.26 82.34,35.01 78.22,30.88 78.19,30.88 77.88,30.58 77.88,30.55 77.19,29.85 55.15,29.85 54.93,30.08 52.53,30.08 51.98,30.63 45.74,30.63 44.23,32.14 40.14,32.14 40.14,32.14 38.7,32.14 38.37,32.46 38.37,32.62 38.18,32.81 37.9,32.81 37.7,32.62 37.7,32.46 37.38,32.14 35.97,32.14 v3(35.64,32.48)
GPIO_0: length 116.9
  TOP w0.203: v1(132.75,37.72) 132.78,37.7 R808.1
  TOP w0.254: U101.K8 v3(36.44,34.08)
  TOP w0.305: 98.62,40.18 R108.2 ; 98.62,40.18 98.62,39.67 R109.1 ; 98.62,40.18 95.2,40.18 P101.4
  L7_SIG w0.114: P101.4 95.07,37.64 126.81,37.64 126.95,37.5 129.07,37.5 129.34,37.76 132.71,37.76 v1(132.75,37.72)
  L8_SIG w0.097: 39.76,33.68 39.41,33.68
  L8_SIG w0.114: 39.76,33.68 39.78,33.68 40.17,33.29 43.14,33.29 43.44,33 46.99,33 48.58,34.58 49.98,34.58 50.29,34.27 51.06,34.27 51.56,34.77 59.37,34.77 60.01,35.41 75.57,35.41 77.35,37.19 77.35,39.47 77.85,39.98 83.89,39.98 84.97,41.06 84.97,42.01 85.54,42.58 90.74,42.58 91.38,43.22 94.24,43.22 95.13,42.33 95.13,40.11 P101.4 ; v3(36.44,34.08) 36.83,33.68 39.41,33.68
GPIO_1: length 129.8
  TOP w0.203: R809.1 132.78,36.43 v1(132.75,36.45)
  TOP w0.254: U101.J8 v3(35.64,34.88)
  TOP w0.305: P101.3 93.52,41.73 R107.1 R106.2
  L7_SIG w0.114: v1(132.75,36.45) 131.09,36.45 130.91,36.62 117.64,36.62 117.63,36.61 94.24,36.61 92.75,38.1 92.75,39.31 92.78,39.33 92.78,39.35 93.86,40.43 P101.3
  L8_SIG w0.114: P101.3 92.62,40.14 92.62,36.39 91.77,35.54 91.77,31.99 90.56,30.78 90.56,30.27 85.86,25.57 59.32,25.57 58.56,24.81 54.49,24.81 54.29,24.61 45.04,24.61 43.45,26.2 42.05,26.2 40.14,28.11 37.6,28.11 36.78,28.94 34.7,28.94 34.37,29.26 34.37,29.42 34.18,29.61 34.03,29.61 33.57,30.06 33.57,30.22 33.38,30.41 33.23,30.41 32.9,30.74 32.9,32.46 34.37,33.94 34.37,34.09 34.75,34.46 34.93,34.46 35.35,34.88 v3(35.64,34.88)
GPIO_2: length 124.6
  TOP w0.203: v1(135.29,38.99) 135.79,38.49 R822.1
  TOP w0.254: U101.J7 v3(34.84,33.28)
  TOP w0.305: R104.2 91.51,36.62 R105.1
  TOP w0.394: P101.6 91.46,38.71 R105.1
  L7_SIG w0.114: P101.6 92.59,40.11 92.59,41.76 93.41,42.58 97.92,42.58 102.27,38.24 126.21,38.24 126.5,38.53 129.81,38.53 130.21,38.94 130.66,38.94 131.2,38.4 134.71,38.4 v1(135.29,38.99)
  L8_SIG w0.114: v3(34.84,33.28) 34.25,33.28 33.66,32.68 33.66,31.54 34.78,30.41 34.98,30.41 35.75,29.64 36.71,29.64 37.41,28.94 39.95,28.94 41.41,27.48 46.49,27.48 47.77,26.2 53.6,26.2 54.54,27.14 84.89,27.14 88.04,30.3 88.04,30.8 90.99,33.76 90.99,35.98 91.32,36.31 P101.6
GPIO_3: length 124.5
  TOP w0.203: R102.2 R103.1 ; v1(132.75,35.18) 133.36,35.79 134.18,35.79 134.88,36.49 R823.1
  TOP w0.254: U101.K7 v3(36.44,33.28)
  TOP w0.305: R103.1 91.29,43.83 91.29,41.41 P101.5
  L7_SIG w0.114: v1(132.75,35.18) 132.54,34.96 119.26,34.96 118.68,34.39 116.16,34.39 115.72,34.83 92.91,34.83 90.21,37.53 90.21,40.27 P101.5
  L8_SIG w0.114: v3(36.44,33.28) 35.97,32.81 35.97,32.34 35.78,32.14 35.63,32.14 35.3,31.82 35.3,31.42 36.3,30.41 36.58,30.41 36.9,30.09 36.9,29.94 37.2,29.64 40.01,29.64 41.28,28.37 48.26,28.37 48.77,27.87 52.21,27.87 52.33,27.99 62.33,27.99 62.33,27.98 83.07,27.98 83.37,28.29 83.37,28.55 90.05,35.22 90.05,40.11 P101.5
GPIO_3P3_0: length 62.6
  TOP w0.254: U101.C1 29.49,27.93 v3(29.35,27.93)
  L8_SIG w0.114: P102.3 65.04,53.76 50.36,53.76 49.98,53.38 48.64,53.38 48.52,53.51 46.87,53.51 46.48,53.13 39.31,53.13 38.01,51.83 38.01,51.55 36.24,49.77 35.86,49.77 35.56,49.47 35.56,48.8 34.23,47.47 34.23,44.7 33.54,44.01 33.54,39.49 31.66,37.61 31.5,37.61 31.3,37.42 31.3,37.22 30.09,36.01 29.9,36.01 29.7,35.82 29.7,35.66 29.4,35.35 29.39,35.35 29.38,35.34 29.23,35.34 28.81,34.92 28.81,33.39 28.04,32.63 28.04,28.39 28.5,27.93 v3(29.35,27.93)
  BOTTOM w0.203: P102.3 C121.1
GPIO_3P3_1: length 54.5
  TOP w0.254: U101.D1 31.2,28.84 v3(31.2,28.31)
  L8_SIG w0.114: v3(31.2,28.31) 30.43,29.09 30.43,34.94 30.83,35.34 30.98,35.34 31.3,35.66 31.3,35.82 32.3,36.81 32.46,36.81 33.7,38.05 33.7,38.15 33.7,38.15 33.7,38.22 33.9,38.41 34.05,38.41 34.5,38.86 34.5,43.19 36.25,44.94 36.52,44.94 37.85,46.27 39.88,46.27 42.17,48.55 59.31,48.55 59.63,48.24 65.09,48.24 P102.4
  BOTTOM w0.203: P102.4 C122.1
GPIO_3P3_2: length 57.6
  TOP w0.254: U101.E1 v3(31.64,29.28)
  L8_SIG w0.114: v3(31.64,29.28) 31.25,29.66 31.25,31.52 31.25,31.52 31.25,34.16 32.18,35.09 32.9,35.09 33.14,35.34 33.38,35.34 33.66,35.62 33.66,35.77 34.03,36.14 34.18,36.14 34.37,36.34 34.37,36.57 34.71,36.9 34.96,36.9 35.3,37.24 35.3,42.45 36.99,44.14 36.99,44.23 38.26,45.51 43.5,45.51 45.91,47.92 48.2,47.92 48.45,47.66 66.23,47.66 67.76,49.19 67.76,50.33 67.12,50.97 65.29,50.97 P102.5
GPIO_3P3_3: length 52.1
  TOP w0.254: U101.C2 v3(30.04,29.28)
  L8_SIG w0.114: P102.6 62.69,51.03 49.28,51.03 48.93,50.68 41.75,50.68 40.91,49.84 40.91,48.64 39.24,46.97 36.27,46.97 34.8,45.51 34.8,44.49 34.05,43.73 34.05,39.42 32.04,37.41 32.04,37.16 30.89,36.01 30.7,36.01 30.5,35.82 30.5,35.66 30.37,35.54 30.18,35.34 29.97,35.34 29.59,34.96 29.59,29.72 v3(30.04,29.28)
GPIO_3P3_4: length 71.3
  TOP w0.254: U101.D2 v3(30.84,29.28)
  L7_SIG w0.114: P102.7 60.34,53.38 48.42,53.38 42.46,59.35 40.07,59.35 39.44,58.71 29.66,58.71 26.61,55.67 26.61,48.87 25.38,47.64 25.38,37.4 26.32,36.46 26.32,34.05 28.1,32.26 28.1,31.35 28.24,31.21 29.38,31.21 29.57,31.02 29.57,30.79 29.9,30.46 30.2,30.46 30.43,30.24 30.43,29.69 v3(30.84,29.28)
  BOTTOM w0.203: P102.7 C123.1
GPIO_3P3_5: length 64.2
  TOP w0.254: U101.E2 v3(31.64,30.08)
  L7_SIG w0.114: P102.8 61.48,49.39 60.52,48.43 48.77,48.43 47.18,50.01 45.66,50.01 41.85,53.82 40.26,53.82 39.14,54.94 34.76,54.94 34.73,54.96 34.31,54.96 34.01,54.67 30.31,54.67 29.59,53.95 29.59,51.22 29.02,50.65 29.02,44.81 29.85,43.97 29.85,42.56 29.47,42.18 29.47,40.17 29.57,40.06 29.57,34.86 29.9,34.54 30.27,34.54 30.48,34.33 30.48,33.31 31.17,32.62 31.17,32.46 31.57,32.06 31.8,32.06 32.03,31.84 32.03,30.46 v3(31.64,30.08)
  BOTTOM w0.203: P102.8 C124.1
GPIO_3P3_6: length 63
  TOP w0.254: U101.E3 v3(31.64,30.88)
  L7_SIG w0.114: P102.9 57.64,50.95 48.34,50.95 46.42,52.87 45.53,52.87 42.17,56.24 35.5,56.24 34.9,55.64 31.23,55.64 31.04,55.44 29.94,55.44 28.64,54.14 28.64,52.94 27.82,52.11 27.82,46.59 26.86,45.63 26.86,43.28 27.21,42.94 27.21,34.54 27.54,34.21 27.96,34.21 28.56,33.61 29.38,33.61 29.57,33.42 29.57,32.39 29.95,32.01 30.18,32.01 30.37,31.82 30.37,31.64 30.81,31.21 31.3,31.21 v3(31.64,30.88)
  BOTTOM w0.203: P102.9 C125.1
GPIO_3P3_7: length 38.1
  TOP w0.254: v3(31.64,38.88) U101.E13
  L5_SIG w0.114: v3(31.64,38.88) 31.97,38.54 32.98,38.54 34.1,39.66 34.1,43.28 36.06,45.25 36.06,45.97 36.36,46.27 40.52,46.27 41.59,47.34 45.65,47.34 46.14,47.83 47.22,47.83 47.71,47.34 57.84,47.34 58.94,48.43 P102.10
  BOTTOM w0.203: P102.10 C126.1
GPIO_3P3_8: length 55.1
  TOP w0.254: v3(30.84,38.88) U101.D13
  L5_SIG w0.114: P102.11 57.66,50.98 57.66,49 57.1,48.43 41.47,48.43 40.01,46.97 36.13,46.97 33.74,44.57 33.74,44.21 33.53,44 33.53,39.76 33.02,39.25 31.21,39.25 v3(30.84,38.88)
  L10_SIG w0.114: P102.11 54.88,53.76 52.83,53.76 47.69,58.9 v2(47.69,61.32)
  BOTTOM w0.203: P102.11 C127.1 ; U102.1 v2(47.69,61.32)
GPIO_3P3_9: length 55.5
  TOP w0.203: C128.1 56.26,49.57 P102.12
  TOP w0.254: v3(30.04,38.88) U101.C13
  L5_SIG w0.114: P102.12 55.18,50.92 55.18,53.19 53.41,54.97 48.96,54.97 46.33,57.6 v2(42.01,57.6) 41.83,57.6 40.28,56.05 35.37,56.05 34.86,55.54 30.16,55.54 28.57,53.94 28.57,52.29 28.2,51.92 28.2,45.63 28.97,44.85 28.97,43.13 28.83,42.99 28.83,42.56 28.97,42.42 28.97,40.42 29.37,40.01 29.38,40.01 29.57,39.82 29.57,39.81 30.04,39.35 v3(30.04,38.88)
  BOTTOM w0.203: v2(42.01,57.6) 43.18,58.78 44.33,58.78
GPIO_3P3_10: length 46.4
  TOP w0.254: U101.D14 v3(30.84,39.68)
  L5_SIG w0.114: P102.13 52.47,53.63 49.61,53.63 49.36,53.38 48.93,53.38 48.36,53.95 47.56,53.95 44.9,56.62 v2(44.33,56.62) 41.59,56.62 39.75,54.78 34.92,54.78 34.73,54.96 34.31,54.96 34.12,54.78 30.39,54.78 29.41,53.8 29.41,50.82 28.89,50.3 28.89,45.82 29.41,45.31 29.41,44.9 29.53,44.78 29.53,43.32 29.85,42.99 29.85,42.56 29.47,42.17 29.47,40.63 30.42,39.68 v3(30.84,39.68)
  BOTTOM w0.203: P102.13 C129.1 ; v2(44.33,56.62) 44.33,57.51
GPIO_3P3_11: length 45.7
  TOP w0.203: P102.14 53.85,49.7 C130.1
  TOP w0.254: U101.E14 v3(31.64,39.68)
  L5_SIG w0.114: v3(31.64,39.68) 31.96,39.68 32.3,40.01 32.43,40.01 32.7,40.28 32.7,46.2 35.56,49.06 35.56,49.47 36.29,50.2 36.71,50.2 37.59,51.09 37.59,51.47 39.37,53.25 41.53,53.25 43.88,55.6 v2(44.83,55.6) 45.09,55.6 47.06,53.63 47.06,52.81 48.45,51.41 50.1,51.41 50.61,50.9 52.66,50.9 P102.14
  BOTTOM w0.203: v2(44.83,55.6) 45.34,55.6 46.99,57.25 46.99,59.03 48.01,60.05 U102.2
GPIO_4: length 113.1
  TOP w0.203: P101.8 88.78,37.02 88.78,37.01 R707.2 ; v1(132.75,30.1) 132.78,30.08 R812.1
  TOP w0.254: U101.K6 v3(36.44,32.48)
  L7_SIG w0.114: v1(132.75,30.1) 130.1,32.75 118.31,32.75 117.69,33.37 113.72,33.37 113.42,33.07 92.32,33.07 88.78,36.61 P101.8
  L8_SIG w0.114: v3(36.44,32.48) 36.44,32.16 36.21,31.93 36.21,31.92 36.1,31.82 36.1,31.54 36.21,31.43 36.2,31.42 36.41,31.21 36.58,31.21 36.9,30.89 36.9,30.74 37.1,30.54 38.98,30.54 39.87,30.54 41.47,28.95 49.36,28.95 49.67,29.26 53.48,29.26 54.18,29.96 55.44,29.96 55.55,29.85 61.22,29.85 62.93,31.56 83.72,31.56 87.62,35.46 88.15,35.46 88.78,36.09 P101.8
GPIO_5: length 63.2
  TOP w0.203: R705.2 89.91,43.67 R813.1
  TOP w0.254: U101.K5 v3(36.44,31.68)
  TOP w0.305: R705.2 88.82,41.42 P101.7
  L8_SIG w0.097: 39.89,31.29 39.51,31.29
  L8_SIG w0.114: P101.7 87.51,40.11 87.51,37.06 85.54,35.1 84.46,35.1 82.25,32.88 61.42,32.88 59.88,31.35 54.3,31.35 53.6,30.65 49.92,30.65 49.67,30.4 40.78,30.4 39.89,31.29 ; 39.51,31.29 37.15,31.29 36.76,31.68 v3(36.44,31.68)
GPIO_6: length 120
  TOP w0.203: R843.1 141.67,33.93 v1(141.65,33.95)
  TOP w0.254: U101.L5 v3(37.24,31.68)
  TOP w0.305: P101.10 86.65,38.44 R706.2
  L7_SIG w0.114: v1(141.65,33.95) 141.11,34.49 141.11,35.06 137.03,39.14 137.03,39.18 135.27,40.93 125.03,40.93 124.03,39.93 123.27,39.93 123.22,39.98 102.94,39.98 99.63,43.28 88.97,43.28 87.51,41.82 87.51,40.11 P101.10
  L8_SIG w0.114: v3(37.24,31.68) 37.61,32.05 39.89,32.05 40.52,31.42 49.28,31.42 49.85,31.98 55.19,31.98 55.32,31.86 56.96,31.86 57.85,32.75 59.77,32.75 60.4,33.39 79.66,33.39 80.16,33.89 80.16,34.01 82.65,36.49 82.81,36.49 82.81,36.5 84.97,36.5 86.24,37.77 P101.10
GPIO_7: length 123.4
  TOP w0.203: R844.1 139.26,31.92 138.69,31.35 v3(137.8,31.35)
  TOP w0.254: U101.L6 v3(37.24,32.48)
  TOP w0.305: R702.2 86.23,43.62 86.23,41.4 P101.9
  L7_SIG w0.114: v3(137.8,31.35) 137.16,30.71 137.16,29.88 136.66,29.38 135.65,29.38 134.49,28.23 132.07,28.23 131.31,28.99 130.7,28.99 130.64,28.93 126.88,28.93 126.17,29.64 121.1,29.64 120.72,29.26 118.93,29.26 117.79,30.39 114.49,30.39 113.6,31.28 91.2,31.28 91.07,31.42 90.43,31.42 89.54,32.3 89.54,32.94 84.97,37.52 84.97,39.54 86.24,40.81 P101.9
  L8_SIG w0.114: v3(37.24,32.48) 37.7,32.94 38.7,32.94 39.76,32.94 40.65,32.05 47.18,32.05 47.25,31.98 48.2,31.98 49.6,33.38 59.38,33.38 60.72,34.72 78.11,34.72 81.03,37.64 84.34,37.64 84.97,38.27 84.97,39.16 86.24,40.43 P101.9
GPIO_8: length 131.5
  TOP w0.203: v1(136.56,30.1) 136.18,29.72 R827.1
  TOP w0.254: U101.L12 v3(37.24,38.08)
  L5_SIG w0.091: v1(136.56,30.1) 136.56,30.8 136.47,30.89 135.86,30.89 135.77,30.8 135.77,29.75 135.96,29.56 138.5,29.56 138.81,29.87 138.81,37.55 136.81,39.54 131.22,39.54 129.95,40.81 124.11,40.81 123.86,41.07 103.13,41.07 101.55,42.65 92.99,42.65 92.41,43.23 85.16,43.23 84.52,42.59 84.52,42.2 84.84,41.89 84.84,40.62 83.7,39.48 P101.12
  L10_SIG w0.091: P101.12 83.7,37.64 82.73,36.67 73.44,36.67 67.41,42.7 56.27,42.7 55.56,43.41 48.83,43.41 48.14,42.71 43.37,42.71 42.74,42.08 38.08,42.08 37.05,41.04 37.05,40.06 37.1,40 37.37,40 37.56,39.81 37.56,38.47 37.42,38.33 37.42,38.26 v3(37.24,38.08)
GPIO_9: length 123
  TOP w0.203: R810.1 134.33,33.6 v1(134.02,33.91)
  TOP w0.254: U101.K12 v3(36.44,38.08)
  L5_SIG w0.091: v1(134.02,33.91) 134.02,33.49 133.93,33.4 132.44,33.4 131.38,34.46 129.27,34.46 124.06,39.66 102.15,39.66 101.58,40.24 85.72,40.24 84.89,39.41 84.89,38.42 84.22,37.76 84.17,37.76 84.16,37.75 83.25,37.75 82.55,38.44 82.55,40.24 P101.11
  L10_SIG w0.091: v3(36.44,38.08) 36.08,38.43 36.08,39.08 35.85,39.31 35.76,39.31 35.66,39.4 35.66,42.39 36.49,43.22 39.35,43.22 40.52,44.39 73.91,44.39 75.72,42.58 79.21,42.58 79.76,42.03 79.76,38.03 80.48,37.31 81.77,37.31 82.55,38.1 82.55,40.24 P101.11
GPIO_10: length 123
  TOP w0.203: v1(134.02,32.64) 134.33,32.33 R811.1
  TOP w0.254: U101.J12 v3(35.64,38.08)
  L5_SIG w0.091: P101.14 81.16,39.89 81.25,39.98 82.21,39.98 82.3,39.89 82.3,38.33 83.14,37.49 84.26,37.49 84.28,37.5 84.33,37.5 85.14,38.32 85.14,39.3 85.82,39.98 101.48,39.98 102.05,39.41 123.95,39.41 129.16,34.2 131.28,34.2 132.33,33.15 133.93,33.15 134.02,33.06 v1(134.02,32.64)
  L10_SIG w0.091: v3(35.64,38.08) 35.31,38.4 35.31,39.07 35.41,39.17 35.41,42.5 36.39,43.47 39.24,43.47 40.42,44.65 74.01,44.65 75.82,42.84 79.31,42.84 80.01,42.14 80.01,38.14 80.58,37.57 81.66,37.57 82.3,38.2 82.3,39.62 82.21,39.71 81.71,39.71 81.16,39.16 P101.14
GPIO_11: length 117.2
  TOP w0.203: R824.1 135.26,35.14 v1(135.29,35.18)
  TOP w0.254: U101.H12 v3(34.84,38.08)
  L5_SIG w0.091: v1(135.29,35.18) 135.71,35.18 135.8,35.09 135.8,33.78 135.46,33.44 135.1,33.44 134.48,32.82 134.48,32.45 134.21,32.19 130.8,32.19 130.01,32.97 128.56,32.97 128.27,32.68 126.94,32.68 122.62,37 118.3,37 117.92,36.62 116.44,36.62 115.59,37.47 87.74,37.47 87.21,36.93 81.28,36.93 80.01,38.2 80.01,40.68 80.72,41.39 P101.13
  L7_SIG w0.091: P101.13 80.52,40.74 80.27,40.74 80.04,40.97 80.04,42.12 79.01,43.16 65.62,43.16 62.74,40.28 45.85,40.28 44.02,38.45 35.21,38.45 35.07,38.31 v3(34.84,38.08)
GPIO_12: length 116.8
  TOP w0.203: R825.1 136.53,35.14 v1(136.56,35.18)
  TOP w0.254: U101.H11 v3(34.84,37.28)
  L5_SIG w0.091: P101.16 79.45,38.85 79.76,38.53 79.76,38.1 81.18,36.68 87.31,36.68 87.85,37.21 115.48,37.21 116.33,36.36 118.03,36.36 118.41,36.74 122.52,36.74 126.83,32.42 128.38,32.42 128.67,32.72 129.91,32.72 130.69,31.93 134.32,31.93 134.73,32.35 134.73,32.71 135.2,33.19 135.57,33.19 136.06,33.67 136.06,35.09 136.15,35.18 v1(136.56,35.18)
  L7_SIG w0.091: v3(34.84,37.28) 35.25,37.69 39.71,37.69 39.92,37.89 39.92,38.06 40.06,38.2 44.13,38.2 45.96,40.02 62.85,40.02 65.72,42.9 78.9,42.9 79.79,42.02 79.79,40.9 78.62,39.73 P101.16
GPIO_13: length 121.4
  TOP w0.203: R831.1 135.32,42.77 v1(135.29,42.8)
  TOP w0.254: U101.J11 v3(35.64,37.28)
  L5_SIG w0.091: v1(135.29,42.8) 135.39,42.9 135.39,43.53 135.75,43.88 135.75,44.26 135.38,44.62 132.5,44.62 131.62,43.73 125.22,43.73 124.71,44.24 116.59,44.24 114.69,42.34 104.66,42.34 102.93,44.06 92.82,44.06 92.14,44.74 78.47,44.74 76.88,43.16 76.31,43.16 75.64,42.49 75.63,42.49 74.98,41.84 74.98,40.61 75.3,40.29 77.52,40.29 P101.15
  L7_SIG w0.091: P101.15 77.47,40.24 77.47,38.26 76.33,37.12 75.42,37.12 73.2,34.9 52.28,34.9 51.74,35.45 49.19,35.45 48.97,35.23 42.55,35.23 42.02,34.7 39.99,34.7 39.79,34.5 39.48,34.5 39.26,34.72 38.77,34.72 38.14,35.35 37.9,35.35 37.71,35.54 37.71,35.78 37.34,36.15 37.1,36.15 36.91,36.34 36.91,36.61 36.83,36.69 36.7,36.69 36.54,36.84 36.07,36.84 v3(35.64,37.28)
GPIO_14: length 121.4
  TOP w0.203: R830.1 136.46,42.7 v1(136.56,42.8)
  TOP w0.254: U101.K11 v3(36.44,37.28)
  L5_SIG w0.091: v1(136.56,42.8) 135.93,42.8 135.64,43.09 135.64,43.42 136,43.78 136,44.36 135.49,44.87 132.4,44.87 131.52,43.99 125.32,43.99 124.81,44.5 116.49,44.5 114.58,42.59 104.76,42.59 103.04,44.32 92.93,44.32 92.25,45 78.36,45 76.77,43.41 76.2,43.41 75.53,42.74 75.52,42.74 74.73,41.95 74.73,40.5 75.2,40.03 77.1,40.03 77.35,39.79 77.35,39.03 77.16,38.85 P101.18
  L7_SIG w0.091: v3(36.44,37.28) 36.47,37.28 36.8,36.94 36.94,36.94 37.08,36.8 37.37,36.8 37.56,36.61 37.56,36.29 37.85,36 38.17,36 38.36,35.81 38.36,35.49 38.88,34.97 39.2,34.97 39.48,35.25 39.79,35.25 40.1,34.95 41.92,34.95 42.45,35.48 48.86,35.48 49.09,35.7 51.84,35.7 52.39,35.16 73.09,35.16 75.31,37.38 76.23,37.38 77.22,38.37 77.22,39.23 77.12,39.33 76.57,39.33 P101.18
GPIO_15: length 131.8
  TOP w0.203: v1(135.29,30.1) 135.62,30.42 R826.1
  TOP w0.254: U101.L11 v3(37.24,37.28)
  L5_SIG w0.091: P101.17 77.28,42.58 84.15,42.58 85.05,43.48 92.51,43.48 93.09,42.9 101.66,42.9 103.24,41.32 123.96,41.32 124.22,41.07 130.06,41.07 131.33,39.8 136.91,39.8 139.06,37.65 139.06,29.76 138.6,29.3 135.86,29.3 135.29,29.87 v1(135.29,30.1)
  L10_SIG w0.091: P101.17 75.64,41.83 75.05,41.83 74.81,41.59 74.81,37.08 74.71,36.99 73.48,36.99 67.51,42.96 56.38,42.96 55.67,43.66 48.73,43.66 48.03,42.97 43.27,42.97 42.63,42.33 37.98,42.33 36.79,41.15 36.79,37.37 36.88,37.28 v3(37.24,37.28)
GPIO_16: length 115.5
  TOP w0.203: R817.1 141.64,48.84 v1(141.64,49.15)
  TOP w0.254: U101.M11 v3(38.04,37.28)
  L5_SIG w0.091: v1(141.64,49.15) 141.27,49.15 141.1,49.32 141.1,49.7 140.85,49.95 132.84,49.95 130.18,52.62 125.39,52.62 123.23,54.78 109.84,54.78 109.2,55.41 102.24,55.41 97.16,50.33 88.9,50.33 87.12,48.55 77.37,48.55 74.19,45.38 73.54,45.38 70.04,41.88 v3(69.67,41.88)
  L7_SIG w0.091: v3(38.04,37.28) 38.35,37.28 38.82,36.8 40.83,36.8 41.09,37.06 48.03,37.06 48.22,37.25 51.59,37.25 52.03,37.7 65.85,37.7 69.67,41.51 v3(69.67,41.88)
GPIO_17: length 115.4
  TOP w0.203: R816.1 140.37,48.84 v1(140.37,49.15)
  TOP w0.254: U101.M10 v3(38.04,36.48)
  L5_SIG w0.091: v1(140.37,49.15) 140.61,49.15 140.85,49.38 140.85,49.59 140.74,49.7 132.74,49.7 130.07,52.36 125.29,52.36 123.13,54.52 109.73,54.52 109.1,55.16 102.34,55.16 97.26,50.08 89.01,50.08 87.23,48.3 77.47,48.3 74.3,45.12 73.64,45.12 71.15,42.64 70.22,41.7 v3(70.22,41.33)
  L7_SIG w0.091: v3(38.04,36.48) 38.38,36.48 38.77,36.09 38.91,36.09 39.16,36.34 39.22,36.34 39.47,36.09 39.75,36.09 39.94,36.28 39.94,36.46 40.02,36.55 40.93,36.55 41.19,36.81 48.14,36.81 48.33,37 51.69,37 52.14,37.44 65.96,37.44 69.85,41.33 v3(70.22,41.33)
GPIO_18: length 34.6
  TOP w0.203: R113.1 58.99,36.42 58.99,35.29 R704.2
  TOP w0.254: U101.J3 v3(34.84,30.88)
  TOP w0.305: P104.4 58.99,38.77 R113.1
  L8_SIG w0.114: v3(34.84,30.88) 34.5,31.21 34.5,31.82 34.83,32.14 34.98,32.14 35.19,32.35 35.19,33.32 36.36,34.49 41.75,34.49 42.67,35.41 48.39,35.41 49.91,36.93 52.07,36.93 52.71,37.57 57.66,37.57 P104.4
  BOTTOM w0.203: R837.1 P104.4
INPUT_VOLTAGE: length 42
  TOP w0.203: CR901.C 121.36,5.44 DS901.A
  TOP w0.305: R714.2 v2(55.9,7.29)
  L7_SIG w0.114: v2(55.9,7.29) 56.41,6.78 60.21,6.78 62.37,4.62 80.18,4.62 v2(84.09,8.52)
  BOTTOM w0.254: U901.22 86.25,9.16 v2(85.59,8.5) ; v2(93.15,12.81) 92.8,13.17 v2(92.49,13.17) ; v2(92.49,13.17) 92.24,12.92 U901.7 ; v2(92.49,13.17) 92.24,13.42 U901.6 ; U901.36 84.03,15.92 83.53,16.42 ; 85.26,17.59 85.75,17.1 U901.38
  BOTTOM w0.394: R909.1 v2(92.94,18.39)
  vias: v2(83.38,18.28) v2(83.71,16.73) v2(84.24,18.28) v2(84.57,16.73) v2(84.82,8.5) v2(98.77,13.32) v2(98.77,12.43) v2(98.77,11.57) v8(117.74,6.02) v8(117.74,4.3) v8(119.26,6.02) v8(119.26,4.3) v8(123.71,6.02) v8(123.71,4.3) v8(125.23,6.02) v8(125.23,4.3)
JTAG_TDI: length 1.6
  TOP w0.305: v1(140.37,22.48) 140.04,22.15 R840.2
  BOTTOM w0.394: v1(140.37,22.48) P801.D30
JTAG_TDO: length 1.6
  TOP w0.305: R840.1 140.07,21.51 v1(140.37,21.21)
  BOTTOM w0.394: v1(140.37,21.21) P801.D31
LDO_VCO_2P5: length 3.2
  BOTTOM w0.203: C416.1 86.25,54.23
  BOTTOM w0.254: U401.15 86.54,55.37 86.54,55.05 86.55,55.04 86.55,54.53 86.24,54.22 C417.1
LF_EXT_CAP: length 2.9
  BOTTOM w0.203: C414.2 90.11,53.81 R439.2
  BOTTOM w0.254: U401.7 90.54,55.18 90.54,54.29 R439.2
LF_PLL2: length 2.3
  BOTTOM w0.254: C416.2 87.24,53.86 87.25,53.85 87.25,54.61 87.04,54.82 U401.14
ORX1_BAL+: length 3.2
  BOTTOM w0.203: 22.04,43.38 21.77,43.85 arc(21.36,44.31) T205.4 ; 22.04,43.38 22.03,43.29 C218.2 ; 22.04,43.38 22.26,43 arc(22.38,42.65) R220.1
ORX1_BAL-: length 3.3
  BOTTOM w0.127: 22.28,43.68 22.38,43.49 C218.1 ; R219.1 23.15,42.73
  BOTTOM w0.203: T205.5 arc(21.88,44.61) 22.07,44.03 22.28,43.68 22.41,43.45 22.51,43.28 22.57,43.17 arc(22.72,42.97) 22.93,42.82 arc(23.03,42.77) 23.15,42.73
ORX1_ENABLE: length 37
  TOP w0.254: U101.M5 v3(38.04,31.68)
  TOP w0.305: P104.7 53.91,41.44 R117.1
  L5_SIG w0.114: P104.7 53.34,41.38 49.86,44.86 40.25,44.86 39.49,44.1 38.35,44.1 35.3,41.05 35.3,34.21 36.06,33.46 36.06,33.14 36.38,32.81 36.58,32.81 36.77,32.62 36.77,32.42 37.15,32.04 37.67,32.04 v3(38.04,31.68)
  BOTTOM w0.203: R839.1 P104.7
ORX1_IN+: length 7.9
  BOTTOM w0.203: 23.44,40.95 23.36,41.1 arc(23.07,41.47) R220.2 ; 23.44,40.95 C221.2 ; 23.44,40.95 23.55,40.72 arc(23.61,40.61) 23.68,40.51 arc(25.7,38.51) 28.43,37.72 arc(28.64,37.71) v5(28.84,37.68)
ORX1_IN-: length 7.8
  BOTTOM w0.203: 23.75,41.11 23.66,41.28 arc(23.5,41.71) R219.2 ; 23.75,41.11 23.86,40.89 arc(23.92,40.79) 23.98,40.7 arc(25.88,38.82) 28.44,38.08 arc(28.53,38.08) 28.61,38.1 arc(28.71,38.15) 28.8,38.21 arc(28.86,38.34) v5(28.84,38.48) ; 23.75,41.11 C221.1
ORX1_UNBAL: length 2.3
  BOTTOM w0.203: 17.98,49.53 C250.1 ; C217.1 17.61,50.43
  BOTTOM w0.305: R216.2 17.22,51.28
  BOTTOM w0.394: 17.22,51.28 17.61,50.43 17.98,49.53
ORX2_BAL+: length 3.1
  BOTTOM w0.203: C225.2 22.54,24.32 ; 22.54,24.32 22.76,24.63 arc(23.02,24.89) R227.1 ; 22.54,24.32 22.19,23.82 arc(21.94,23.26) 21.93,22.65
ORX2_BAL-: length 3.1
  BOTTOM w0.203: C225.1 22.25,24.53 ; 22.25,24.53 22.46,24.83 arc(22.61,25.18) R226.1 ; 22.25,24.53 22.16,24.4 21.9,24.02 arc(21.46,23.6) 20.89,23.38
