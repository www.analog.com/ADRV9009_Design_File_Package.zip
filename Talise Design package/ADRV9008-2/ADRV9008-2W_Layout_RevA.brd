# Allegro board ADRV9008-2W_Layout_RevA.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ORX2_ENABLE: length 31.3
  TOP w0.254: U101.M7 v3(38.04,34.08)
  TOP w0.305: R116.1 53.91,38.77 P104.8
  L5_SIG w0.114: P104.8 52.58,40.11 50.93,40.11 48.19,42.85 43.44,42.85 43.05,42.45 38.6,42.45 36.84,40.69 36.84,35.53 37.08,35.29 37.37,35.29 37.66,35 37.66,34.46 v3(38.04,34.08)
  BOTTOM w0.203: R842.1 P104.8
ORX2_IN+: length 7.6
  BOTTOM w0.203: C228.2 24.12,26.59 ; 24.12,26.59 arc(24.04,26.46) 23.95,26.33 arc(23.81,26.01) 23.74,25.66 arc(23.74,25.6) R227.2 ; 24.12,26.59 arc(25.79,28.49) 27.87,29.94 arc(28.14,30.04) 28.43,30.08 arc(28.52,30.07) 28.61,30.05 arc(28.71,30.01) 28.8,29.94 arc(28.86,29.81) v5(28.84,29.68)
ORX2_IN-: length 7.7
  BOTTOM w0.203: C228.1 23.82,26.79 ; 23.82,26.79 arc(25.55,28.76) 27.71,30.25 arc(28.06,30.39) 28.43,30.43 arc(28.64,30.44) v5(28.84,30.48) ; 23.82,26.79 arc(23.74,26.66) 23.65,26.53 arc(23.36,26.23) R226.2
ORX2_UNBAL: length 2.3
  BOTTOM w0.203: C251.1 18.65,18
  BOTTOM w0.394: 18.65,18 C224.1 17.76,17.01 R223.2
OUT1: length 3.9
  BOTTOM w0.203: 96.65,60.56 96.63,60.58 R418.1 ; 96.65,60.56 95.11,60.56 95.04,60.63 U401.64 ; 96.65,60.56 96.97,60.56 97.16,60.56 97.47,60.87 R420.1
OUT1_N: length 4
  BOTTOM w0.203: U401.65 95.04,60.13 95.11,60.2 96.65,60.2 ; 96.65,60.2 96.63,60.18 R418.2 ; 96.65,60.2 97.13,60.2 97.47,59.86 R419.1
OUT3: length 3.9
  BOTTOM w0.203: 96.72,63.56 R423.2 ; 96.72,63.56 97.57,63.56 R424.1 ; 96.72,63.56 95.16,63.56 95.09,63.63 94.47,63.63 U401.58
OUT3_N: length 3.9
  BOTTOM w0.203: R425.1 97.57,63.2 96.72,63.2 ; 96.72,63.2 95.16,63.2 95.09,63.13 U401.59 ; 96.72,63.2 R423.1
OUT5: length 19.1
  TOP w0.203: R426.1 91,66.78 ; 91,66.78 90.93,66.84 v2(90.93,67.34) ; 91,66.78 91.11,66.66 91.11,66.14 91.52,65.72 94.21,65.72 95.25,64.68 103.25,64.68 103.66,65.09 105.22,65.09 105.42,64.89 105.42,64.65 105.16,64.38 C410.1
  BOTTOM w0.203: U401.49 91.04,66.29 91.11,66.36 91.11,67.17 v2(90.93,67.34)
OUT5_N: length 19.1
  TOP w0.203: v2(91.65,67.34) 91.65,66.84 91.63,66.83 ; R426.2 91.63,66.82 91.63,66.83 ; C411.1 106.05,64.38 105.78,64.65 105.78,65.03 105.37,65.44 103.51,65.44 103.11,65.04 95.4,65.04 94.36,66.08 91.67,66.08 91.47,66.28 91.47,66.66 91.63,66.83
  BOTTOM w0.203: U401.50 91.54,66.26 91.47,66.33 91.47,67.17 v2(91.65,67.34)
OUT7: length 13.9
  TOP w0.203: 87.95,66.83 88.11,66.66 88.11,66.28 87.91,66.08 85.92,66.08 85.35,66.65 80.13,66.65 79.82,66.97 78.91,66.97 78.5,66.56 78.5,66.21 C412.1 ; 87.95,66.83 R427.1 ; 87.95,66.83 87.93,66.84 v2(87.93,67.34)
  BOTTOM w0.203: U401.43 88.04,66.26 88.11,66.33 88.11,67.17 v2(87.93,67.34)
OUT7_N: length 13.8
  TOP w0.203: 88.58,66.78 88.47,66.66 88.47,66.14 88.06,65.72 85.77,65.72 85.2,66.3 79.99,66.3 79.67,66.61 79.06,66.61 78.86,66.41 78.86,66.21 C413.1 ; 88.58,66.78 R427.2 ; 88.58,66.78 88.65,66.84 v2(88.65,67.34)
  BOTTOM w0.203: v2(88.65,67.34) 88.47,67.17 88.47,66.36 88.54,66.29 U401.44
OUT8: length 22.7
  TOP w0.203: R429.1 69.59,66.06 69.59,66.35 69.45,66.49 68.87,66.49 68.75,66.61 68.75,67.01 69.49,67.76 69.9,67.76 70.18,67.48 70.58,67.48 70.86,67.76 85.73,67.76 ; 85.73,67.76 86.57,67.76 86.79,67.53 86.79,67.16 86.66,67.04 86.66,66.95 86.55,66.84 v2(86.43,66.84) ; 85.73,67.76 R428.1
  BOTTOM w0.203: v2(86.43,66.84) 86.61,66.66 86.61,66.33 86.54,66.26 U401.40
OUT8_N: length 22.7
  TOP w0.203: R430.1 68.39,67.16 69.34,68.11 85.73,68.11 ; 85.73,68.11 86.71,68.11 87.15,67.68 v2(87.15,66.84) ; 85.73,68.11 R428.2
  BOTTOM w0.203: U401.41 87.04,66.29 86.97,66.36 86.97,66.66 v2(87.15,66.84)
OUT12: length 7.1
  BOTTOM w0.203: R431.2 80.57,63.56 ; 80.57,63.56 82.03,63.56 82.26,63.33 82.26,61.65 82.7,61.2 83.47,61.2 83.54,61.13 U401.28 ; 80.57,63.56 80.01,63.56 79.77,63.32 R432.1
OUT12_N: length 7.2
  BOTTOM w0.203: 80.58,63.92 80.05,63.92 79.76,64.21 R433.1 ; 80.58,63.92 80.57,63.93 R431.1 ; 80.58,63.92 82.17,63.92 82.62,63.48 82.62,61.79 82.85,61.56 83.47,61.56 83.54,61.63 U401.29
OUT13: length 3.9
  BOTTOM w0.203: R434.1 81.75,59.71 ; 81.75,59.71 83.63,59.71 83.72,59.63 U401.25 ; 81.75,59.71 81.06,59.71 R436.1
OUT13_N: length 3.9
  BOTTOM w0.203: R435.1 81.06,60.07 81.75,60.07 ; R434.2 81.75,60.07 ; 81.75,60.07 83.62,60.07 83.68,60.13 U401.26
PWRSUPPLYENABLE: length 111.8
  TOP w0.305: R902.1 79.66,19.07 v2(79.68,19.06)
  L8_SIG w0.394: v2(79.68,19.06) 79.73,19.11 97.31,19.11 98.31,20.11 115.71,20.11 116.34,19.48 119.54,19.48 119.55,19.47 120.09,19.47 120.1,19.48 121.39,19.48 121.66,19.75 122.42,19.75 123.59,18.58 127.02,18.58 127.56,18.04 138.89,18.04 141.39,20.54 141.98,20.54 142.31,20.87 142.31,21.46 142.66,21.81 143.19,21.81 143.58,22.2 143.58,32.24 145.04,33.69 145.04,48.45 143.58,49.9 143.58,59.6 142.31,60.87 v1(140.3,60.87)
  BOTTOM w0.394: v1(140.3,60.87) 139.74,60.31 P801.D1
REF_CLK_IN+: length 62.9
  BOTTOM w0.203: C445.2 78.74,59.71 ; 78.74,59.71 77.41,59.71 ; 78.74,59.71 79.47,59.71 R436.2 ; L401.1 77.41,59.71 ; 77.41,59.71 77.09,59.71 arc(72.18,59.25) 67.44,57.88 arc(67.04,57.73) 66.63,57.6 66.64,57.6 arc(58.87,55.89) 50.94,55.27 50.94,55.27 arc(47.52,53.86) 46.11,50.44 46.11,45.64 arc(44.94,42.82) 42.12,41.65 38.29,41.65 arc(35.41,41.03) 33.1,39.2 arc(32.44,38) 32.21,36.64 32.21,35.86 ; 32.21,35.86 32.21,35.59 arc(32.24,35.42) C103.1 ; 32.21,35.86 R121.1
REF_CLK_IN-: length 63.5
  BOTTOM w0.203: R435.2 79.47,60.07 78.74,60.07 ; R121.2 31.85,35.86 ; 31.85,35.86 31.85,35.59 arc(31.81,35.42) C104.1 ; 31.85,35.86 31.85,36.64 arc(32.1,38.12) 32.83,39.43 arc(35.26,41.35) 38.29,42 42.12,42 arc(44.69,43.07) 45.75,45.64 45.75,50.44 arc(47.27,54.11) 50.94,55.62 arc(58.82,56.24) 66.54,57.94 arc(66.93,58.06) 67.31,58.21 arc(72.11,59.6) 77.09,60.07 77.41,60.07 ; 78.74,60.07 C445.1 ; 78.74,60.07 77.41,60.07 ; 77.41,60.07 L401.2
RESETB: length 120
  TOP w0.254: U101.J4 v3(35.64,31.68)
  TOP w0.394: TP803.1 128.99,48.07 129.42,48.5 R804.1
  L5_SIG w0.114: v3(35.64,31.68) 36.08,31.23 38.14,31.23 38.44,31.53 38.44,31.81 38.74,32.11 39,32.11 39.22,32.34 39.22,33.91 39.23,33.92 39.23,34.74 38.44,35.52 38.44,39.08 38.65,39.28 39.89,39.28 40.83,40.22 v5(40.9,40.22) 48.34,40.22 51.1,37.46 68.6,37.46 72.43,41.29 72.43,41.85 73.08,42.5 73.51,42.5 74.93,43.92 76.2,43.92 78.35,46.07 88.39,46.07 88.74,46.43 101.89,46.43 107.63,52.17 113.92,52.17 114.81,51.28 120.46,51.28 123.68,48.07 TP803.1
  BOTTOM w0.305: v5(40.9,40.22) 40.9,39.35 40.16,38.61 R110.2
RF_EXT_LO+: length 5.8
  TOP w0.203: U101.B8 v3(29.24,34.88)
  L10_SIG w0.254: v5(25.19,34.37) 25.47,34.09 27.83,34.09 27.98,34.24 28.89,34.24 29.24,34.58 v3(29.24,34.88)
  BOTTOM w0.203: C304.2 v5(25.19,34.37)
RF_EXT_LO-: length 5.8
  TOP w0.203: U101.B7 v3(29.24,33.28)
  L10_SIG w0.254: v3(29.24,33.28) 29.24,33.61 28.96,33.89 28.13,33.89 27.97,33.73 25.47,33.73 v5(25.19,33.45)
  BOTTOM w0.203: C305.2 v5(25.19,33.45)
RF_SYNTH_VTUNE: length 29.9
  TOP w0.203: P104.5 56.46,41.45 C136.1
  TOP w0.254: v5(34.04,35.68) U101.G9
  L7_SIG w0.114: v5(34.04,35.68) 34.42,36.06 34.42,38.13 34.83,38.54 34.98,38.54 35.18,38.74 35.18,38.9 35.56,39.28 42.99,39.28 44.9,41.19 46.99,41.19 48.33,42.52 51.95,42.52 52.13,42.34 53.24,42.34 53.48,42.58 55.18,42.58 P104.5
RFO_1: length 1
  TOP w0.203: 35.5,52.39 C337.1 ; 35.49,51.45 35.5,51.8
  TOP w0.394: 35.5,51.8 35.5,52.39
RFO_2: length 1
  TOP w0.203: 34.18,16.7 34.18,16.35 ; 34.17,15.77 C336.1
  TOP w0.394: 34.18,16.35 34.17,15.77
SERDIN0+: length 3
  BOTTOM w0.203: P801.A22 143.55,33.02 arc(143.61,32.88) 143.75,32.82 145.7,32.82 arc(145.87,32.85) 146.02,32.95 C113.1
SERDIN0-: length 3
  BOTTOM w0.203: P801.A23 143.55,32.26 arc(143.61,32.4) 143.75,32.46 145.7,32.46 arc(145.87,32.43) 146.02,32.33 C114.1
SERDIN1+: length 3
  BOTTOM w0.203: P801.A30 143.55,22.86 arc(143.61,22.72) 143.75,22.66 145.7,22.66 arc(145.87,22.69) 146.02,22.79 C115.1
SERDIN1-: length 3
  BOTTOM w0.203: C116.1 146.02,22.17 arc(145.87,22.27) 145.7,22.3 143.75,22.3 arc(143.61,22.24) 143.55,22.1 P801.A31
SERDIN2+: length 1.4
  TOP w0.203: v1(141.64,58.04) C117.1
  BOTTOM w0.203: P801.C2 v1(141.64,58.04)
SERDIN2-: length 1.7
  TOP w0.203: v1(141.64,56.77) C118.1
  BOTTOM w0.203: 141.19,57.22 141.19,57.24 141.03,57.4 P801.C3 141.19,57.22 ; 141.19,57.22 v1(141.64,56.77)
SERDIN3+: length 3
  BOTTOM w0.203: C119.1 146.02,27.87 arc(145.87,27.77) 145.7,27.74 143.75,27.74 arc(143.61,27.8) 143.55,27.94 P801.A26
SERDIN3-: length 3
  BOTTOM w0.203: P801.A27 143.55,27.18 arc(143.61,27.32) 143.75,27.38 145.7,27.38 arc(145.87,27.35) 146.02,27.25 C120.1
SERDOUT0+: length 3
  BOTTOM w0.203: P801.A2 143.55,58.42 arc(143.61,58.28) 143.75,58.22 145.7,58.22 arc(145.87,58.25) 146.02,58.35 C105.1
SERDOUT0-: length 3
  BOTTOM w0.203: C106.1 146.02,57.73 arc(145.87,57.83) 145.7,57.86 143.75,57.86 arc(143.61,57.8) 143.55,57.66 P801.A3
SERDOUT1+: length 3
  BOTTOM w0.203: C107.1 146.02,53.27 arc(145.87,53.17) 145.7,53.14 143.75,53.14 arc(143.61,53.2) 143.55,53.34 P801.A6
SERDOUT1-: length 3
  BOTTOM w0.203: C108.1 146.02,52.65 arc(145.87,52.75) 145.7,52.78 143.75,52.78 arc(143.61,52.72) 143.55,52.58 P801.A7
SERDOUT2+: length 1.4
  TOP w0.203: C109.1 141.67,52.93 v1(141.67,52.95)
  BOTTOM w0.203: v1(141.67,52.95) 141.66,52.95 P801.C6
SERDOUT2-: length 1.4
  TOP w0.203: v1(141.64,51.69) C110.1
  BOTTOM w0.203: v1(141.64,51.69) P801.C7
SERDOUT3+: length 3
  BOTTOM w0.203: C111.1 146.02,48.19 arc(145.87,48.09) 145.7,48.06 143.75,48.06 arc(143.61,48.12) 143.55,48.26 P801.A10
SERDOUT3-: length 3
  BOTTOM w0.203: C112.1 146.02,47.57 arc(145.87,47.67) 145.7,47.7 143.75,47.7 arc(143.61,47.64) 143.55,47.5 P801.A11
SPI_CLK: length 112.9
  TOP w0.254: U101.K9 v3(36.44,35.68) ; TP805.1 121.68,44.26 121.68,46.4 120.14,47.94 U403.3
  TOP w0.305: TP805.1 121.6,41.95 129.64,41.95 131.17,43.47 R806.1
  L7_SIG w0.114: TP805.1 119.37,41.95 105.16,41.95 100.9,46.2 89.79,46.2 v4(89.47,45.89)
  L8_SIG w0.114: v4(89.47,45.89) 89.29,46.07 77.72,46.07 77.09,45.44 72.39,45.44 70.36,43.41 51.69,43.41 45.21,36.93 43.18,36.93 41.54,35.29 37.08,35.29 36.69,35.68 v3(36.44,35.68)
SPI_CLK_9528: length 43.5
  TOP w0.203: U403.12 v2(120.14,53.63)
  L7_SIG w0.114: v2(82.21,58.29) 82.42,58.08 83.76,58.08 87.82,54.01 98.43,54.01 98.81,53.63 v2(120.14,53.63)
  BOTTOM w0.254: U401.22 83.47,58.13 83.38,58.04 82.46,58.04 v2(82.21,58.29)
SPI_CS0: length 119.8
  TOP w0.254: U101.K10 v3(36.44,36.48) ; U402.7 116.71,47.86 117.33,47.24 118.65,47.24 119.9,45.99 TP816.1 ; v1(139.1,42.87) 138.89,42.87 138.55,42.53 R832.2 R846.1
  L7_SIG w0.114: v4(88.2,47.54) 96.01,47.54 96.52,47.03 101.6,47.03 105.67,42.97 115,42.97 116.88,44.84 119.34,44.84 TP816.1
  L8_SIG w0.114: v3(36.44,36.48) 36.84,36.88 40.01,36.88 40.36,37.22 40.43,37.22 43.42,40.22 44.88,40.22 48.96,44.3 68.84,44.3 72.08,47.54 v4(88.2,47.54)
  L8_SIG w0.254: TP816.1 121.98,44.49 123.63,44.49 124.64,43.48 138.49,43.48 v1(139.1,42.87)
SPI_CS1: length 34.8
  TOP w0.254: 121.44,50.48 U403.5
  TOP w0.305: U402.1 120.6,51.32 121.44,50.48 122.03,51.08 123.99,51.08 TP815.1 130.59,49.7 130.74,49.86 134.53,49.86 135.89,48.49 135.89,47.6 136.27,47.22 136.74,47.22 137.12,46.84 137.12,40.05 137.5,39.67 138.21,39.67 138.55,40.01 R833.2 R847.1
SPI_CS_9528: length 46.6
  TOP w0.203: U403.10 v2(121.44,53.63)
  L7_SIG w0.114: v2(81.7,57.55) 83.33,57.55 87.31,53.58 87.4,53.58 87.6,53.38 98.05,53.38 98.68,52.74 103.63,52.74 104.14,52.24 105.03,52.24 105.54,52.74 114.81,52.74 115.06,53 120.8,53 v2(121.44,53.63)
  BOTTOM w0.254: v2(81.7,57.55) 83.62,57.55 83.69,57.63 83.78,57.63 U401.21
SPI_DIN: length 114.2
  TOP w0.254: U403.4 120.79,48.18 123,45.96 TP806.1 ; U101.J9 v3(35.64,35.68)
  TOP w0.305: TP806.1 125.39,43.98 129.45,43.98 130.14,44.67 R807.1
  L7_SIG w0.114: TP806.1 122.03,47.33 117.4,47.33 113.93,43.86 106.18,43.86 102.24,47.8 96.97,47.8 96.58,48.19 85.49,48.19 v3(84.01,46.71)
  L8_SIG w0.114: v3(84.01,46.71) 84,46.7 72.45,46.7 69.6,43.85 49.98,43.85 44.33,38.2 43.06,38.2 41.33,36.48 40.85,36.48 40.43,36.06 36.03,36.06 v3(35.64,35.68)
SPI_DIN_9528: length 42.5
  TOP w0.203: U403.11 v2(120.79,56.55)
  L7_SIG w0.114: v2(83.28,58.63) 83.36,58.71 85.09,58.71 87.88,55.93 93.72,55.93 94.62,55.03 109.1,55.03 109.35,54.78 119.01,54.78 v2(120.79,56.55)
  BOTTOM w0.254: v2(83.28,58.63) 83.68,58.63 U401.23
SPI_DOUT: length 31.1
  TOP w0.203: 117.59,45.99 TP811.1 ; 116.2,48.63 U402.6
  TOP w0.254: R845.1 136.06,45.94 136.06,44.09 135.51,43.54 135.26,43.54 134.53,42.81 134.53,42.56 134.13,42.16 133.69,42.16 132.84,41.31 119.6,41.31 118.66,42.26 118.66,44.92 116.19,47.39 116.19,48.62 116.21,48.65 U402.3
SPI_DOUT_9528: length 38.8
  TOP w0.203: TP400.1 114.11,55.92 R453.2
  L7_SIG w0.114: v2(82.56,58.95) 83.01,59.4 86.06,59.4 86.49,58.97 93.73,58.97 96.78,55.92 TP400.1
  BOTTOM w0.254: U401.24 83.81,59.13 83.67,59.13 83.59,59.21 82.83,59.21 v2(82.56,58.95)
SPI_DOUT_DUT: length 91.5
  TOP w0.254: U101.J10 v3(35.64,36.48) ; R454.2 116.07,44.56 TP401.1
  L7_SIG w0.097: 39.49,33.69 39.89,33.69
  L7_SIG w0.114: 39.89,33.69 42.67,33.69 43.2,34.22 44.45,34.22 44.71,33.96 45.3,33.96 45.85,33.41 74.6,33.41 77.03,35.84 77.03,35.98 78.43,37.38 v2(79.64,37.38) ; 39.49,33.69 37.95,33.69 37.63,34.01 37.63,34.24 37.4,34.46 37.1,34.46 36.07,35.5 36.07,36.04 v3(35.64,36.48)
  BOTTOM w0.394: v2(79.64,37.38) 111.83,37.38 TP401.1
STATUS_0: length 3.2
  TOP w0.203: R444.1 v2(95.57,65.95)
  BOTTOM w0.254: U401.55 94.75,65.13 v2(95.57,65.95) ; R444.1 95.57,66.59
  BOTTOM w0.394: 95.57,66.59 v2(95.57,65.95)
STATUS_1: length 4.5
  TOP w0.203: v2(96.64,65.95) 96.64,66.69 R445.1
  BOTTOM w0.254: v2(96.64,65.95) 96.52,65.95 95.2,64.63 U401.56
  BOTTOM w0.394: v2(96.64,65.95) R443.1
SYNCINB0+: length 148.6
  TOP w0.203: v1(137.83,49.15) 137.81,49.13 R820.1
  TOP w0.254: U101.M4 v3(38.04,30.88)
  L7_SIG w0.091: TP809.1 127.14,16.3 ; 127.14,16.3 126.63,15.79 119.66,15.79 116.24,19.22 113.19,19.22 111.79,20.62 110.14,20.62 105.19,25.57 60.57,25.57 59.68,24.68 49.14,24.68 46.23,27.6 44.96,27.6 44.57,27.98 40.77,27.98 39.84,28.92 37.93,28.92 37.71,29.15 37.71,30.21 38.04,30.55 v3(38.04,30.88) ; 127.14,16.3 127.77,16.94 132.45,16.94 136.77,21.26 137.78,21.26 139.91,23.39 139.91,26.5 141.36,27.95 141.97,27.95 143.75,29.73 143.75,48.07 143.14,48.69 138.29,48.69 v1(137.83,49.15)
SYNCINB0-: length 147.4
  TOP w0.203: v1(137.83,47.88) 137.81,47.86 R821.1
  TOP w0.254: U101.M3 v3(38.04,30.08)
  L7_SIG w0.091: 126.96,16.48 127.67,17.19 132.34,17.19 136.66,21.51 137.68,21.51 139.66,23.49 139.66,26.61 141.26,28.21 141.87,28.21 143.5,29.84 143.5,47.97 143.03,48.44 138.19,48.44 137.93,48.69 137.8,48.69 137.42,48.31 137.42,48 137.55,47.88 137.83,47.88 v1(137.83,47.88) ; 126.96,16.48 126.96,16.48 126.52,16.05 119.77,16.05 116.34,19.48 113.29,19.48 111.9,20.87 110.25,20.87 105.29,25.83 60.46,25.83 59.57,24.94 49.25,24.94 46.34,27.85 45.07,27.85 44.68,28.24 40.87,28.24 40.09,29.02 40.09,29.3 39.76,29.62 38.14,29.62 38.04,29.72 v3(38.04,30.08) ; 126.96,16.48 TP810.1
SYNCINB1+: length 107.9
  TOP w0.203: v1(134.02,26.29) 134.46,26.73 R828.1
  TOP w0.254: U101.L4 v3(37.24,30.88)
  L7_SIG w0.091: 116.02,21.44 116.02,21.58 TP812.1 ; 116.02,21.44 115.71,21.13 114.54,21.13 113.4,22.27 111.01,22.27 109.02,24.26 108.88,24.26 105.28,27.86 49.54,27.86 48.4,29 46.08,29 44.05,31.03 40.01,31.03 39.77,31.28 38.62,31.28 38.36,31.54 38.36,31.81 38.17,32 37.9,32 37.66,31.76 37.66,31.33 37.33,30.99 37.33,30.96 v3(37.24,30.88) ; 116.02,21.44 116.66,22.08 119.06,24.49 120.63,24.49 121.39,23.73 122.87,23.73 123.26,24.11 124.38,24.11 125.01,23.47 127.38,23.47 128.4,24.49 131.89,24.49 133.19,25.78 133.93,25.78 134.02,25.87 v1(134.02,26.29)
SYNCINB1-: length 107.8
  TOP w0.203: v1(134.02,25.02) 134.47,25.47 R829.1
  TOP w0.254: U101.L3 v3(37.24,30.08)
  L7_SIG w0.091: TP813.1 117.55,21.19 116.84,21.9 ; 116.84,21.9 119.17,24.23 120.52,24.23 121.29,23.47 122.98,23.47 123.36,23.85 124.27,23.85 124.91,23.22 127.49,23.22 128.5,24.23 132,24.23 133.29,25.53 133.77,25.53 134.02,25.28 v1(134.02,25.02) ; 116.84,21.9 115.81,20.87 114.44,20.87 113.29,22.02 110.9,22.02 108.92,24 108.78,24 105.18,27.61 49.43,27.61 48.29,28.75 45.98,28.75 43.95,30.78 40.01,30.78 39.76,30.53 38.73,30.53 38.36,30.89 38.36,31.01 38.17,31.2 37.89,31.2 37.58,30.89 37.58,30.76 37.56,30.74 37.56,30.74 37.24,30.42 v3(37.24,30.08)
SYNCOUTB0+: length 104.8
  TOP w0.203: TP801.1 128.63,52.83 R802.1 ; U101.M14 v3(37.24,38.88)
  L8_SIG w0.091: TP801.1 127.8,52.54 127.71,52.45 126.03,52.45 123.83,54.65 118.87,54.65 117.99,53.76 100.59,53.76 100.38,53.96 72.09,53.96 71.64,53.51 71.64,48.62 69.22,46.2 49.21,46.2 47.69,44.68 46.29,44.68 42.42,40.81 42.42,40.53 40.87,38.98 40.19,38.98 39.88,39.29 38.72,39.29 38.42,39.59 37.78,39.59 37.54,39.35 37.54,39.1 37.31,38.88 v3(37.24,38.88)
SYNCOUTB0-: length 104.7
  TOP w0.203: U101.M13 v3(38.04,38.88) ; R803.1 128.65,51.84 TP802.1
  L8_SIG w0.091: v3(38.04,38.88) 37.96,38.88 37.8,39.04 37.8,39.24 37.89,39.33 38.32,39.33 38.46,39.18 38.46,38.78 38.67,38.58 38.68,38.58 38.7,38.55 38.97,38.55 39,38.58 39.99,38.58 40.14,38.73 40.98,38.73 42.67,40.43 42.67,40.7 46.4,44.43 47.8,44.43 49.32,45.95 69.32,45.95 71.89,48.52 71.89,53.41 72.19,53.71 100.28,53.71 100.48,53.51 118.09,53.51 118.98,54.4 123.72,54.4 125.92,52.2 127.71,52.2 127.8,52.11 TP802.1
SYNCOUTB1+: length 178.6
  TOP w0.203: R814.1 133.97,24.42 133.48,23.93 130.54,23.93 128.97,25.5 126.95,25.5 126.64,25.81 126.3,25.94 126.19,26.21 TP807.1
  TOP w0.254: U101.L14 v5(37.24,39.68)
  L8_SIG w0.091: v5(37.24,39.68) 37.24,39.95 37.15,40.04 36.92,40.04 36.83,39.95 36.83,39.29 36.74,39.2 36.45,39.2 36.07,39.58 36.07,40.17 40.29,44.39 44.61,44.39 46.29,46.08 47.88,46.08 48.58,46.78 68.33,46.78 70.49,48.93 70.49,53.61 70.23,53.87 70.23,55.18 70.72,55.67 82.32,55.67 82.45,55.54 94.51,55.54 95.02,55.03 107.8,55.03 110.47,57.7 126.39,57.7 131.45,52.64 131.45,51.73 133.51,49.67 141.73,49.67 141.76,49.66 141.76,49.65 141.83,49.6 143.43,48 143.43,34.53 142.13,33.23 142.13,26.26 141.59,25.73 141.35,25.73 140.94,25.31 140.94,24.94 140.56,24.57 127.94,24.57 126.61,25.89 126.3,25.89 126.18,25.94 126.13,26.06 TP807.1
SYNCOUTB1-: length 178.7
  TOP w0.203: TP808.1 125.91,25.5 126.17,25.61 126.44,25.51 126.8,25.15 128.82,25.15 130.39,23.58 133.48,23.58 133.97,23.09 R815.1
  TOP w0.254: U101.L13 v5(36.44,38.88)
  L8_SIG w0.091: TP808.1 125.97,25.65 126.09,25.7 126.25,25.64 126.51,25.64 127.83,24.31 140.67,24.31 141.19,24.84 141.19,25.21 141.46,25.47 141.7,25.47 142.38,26.15 142.38,33.13 143.68,34.43 143.68,48.11 142.32,49.47 141.98,49.81 141.98,49.81 141.94,49.86 141.92,49.86 141.9,49.86 141.9,49.86 141.81,49.92 133.61,49.92 131.7,51.83 131.7,52.74 126.49,57.95 110.37,57.95 107.7,55.28 95.13,55.28 94.62,55.79 82.55,55.79 82.43,55.92 70.61,55.92 69.98,55.28 69.98,53.76 70.23,53.51 70.23,49.04 68.22,47.03 48.47,47.03 47.78,46.33 46.19,46.33 44.5,44.65 40.18,44.65 35.82,40.28 35.82,39.48 36.34,38.96 36.36,38.96 v5(36.44,38.88)
SYSREF_CLK_IN+: length 2.4
  BOTTOM w0.203: R451.2 96.2,57.56 95.11,57.56 95.04,57.63 U401.70
SYSREF_CLK_IN-: length 2.4
  BOTTOM w0.203: U401.71 95.04,57.13 95.11,57.2 96.02,57.2 96.03,57.19 96.15,57.19 R452.2
SYSREF_IN+: length 89.9
  TOP w0.254: U101.K3 v3(36.44,30.08)
  L7_SIG w0.091: v3(36.44,30.08) 36.44,30.15 36.01,30.58 35.65,30.58 34.95,31.28 34.75,31.28 34.51,31.52 34.51,32.59 33.35,33.75 33.1,33.75 32.91,33.94 32.91,34.19 32.51,34.58 32.51,35.37 31.86,36.02 31.86,36.83 32.66,37.63 32.66,38.52 36.47,42.33 43.84,42.33 46.12,44.62 64.28,44.62 67.05,47.39 80.4,47.39 82.25,49.24 82.25,53.93 80.27,55.92 80.27,58.71 77.98,61 77.98,62.02 76.46,63.54 74.08,63.54 v2(73.88,63.33)
  BOTTOM w0.203: R432.2 77.89,63.32 77.64,63.56 74.1,63.56 v2(73.88,63.33)
SYSREF_IN-: length 89.8
  TOP w0.254: U101.K4 v3(36.44,30.88)
  L7_SIG w0.091: v2(73.88,64.15) 74.23,63.79 76.56,63.79 78.23,62.12 78.23,61.11 80.52,58.82 80.52,56.03 82.51,54.04 82.51,49.14 80.5,47.13 67.15,47.13 64.38,44.36 46.23,44.36 43.94,42.08 36.58,42.08 32.91,38.41 32.91,37.52 32.11,36.72 32.11,36.13 32.77,35.47 32.77,34.69 33.06,34.4 33.37,34.4 33.56,34.21 33.56,33.89 34.66,32.8 34.67,32.8 34.97,32.8 35.16,32.61 35.16,31.43 35.76,30.83 36.39,30.83 v3(36.44,30.88)
  BOTTOM w0.203: v2(73.88,64.15) 74.1,63.92 77.6,63.92 77.89,64.21 R433.2
TEST: length 176.3
  TOP w0.203: R836.1 135.38,40.87 137.79,38.46 140.98,38.46
  TOP w0.254: U101.J6 v3(35.64,33.28)
  TOP w0.394: R112.1 R111.2 143.55,11.65 144.95,13.05 144.95,20.46 143.61,21.8 143.61,28.09 142.12,29.57 142.12,30.63 140.98,31.78 140.98,38.46 142.34,39.82 142.34,44.65 v1(141.67,45.32)
  L7_SIG w0.114: v1(141.67,45.32) 140.9,46.09 133.67,46.09 133.31,46.45 126.8,46.45 124.46,44.11 TP817.1 122.62,42.27 121.67,41.31 104.4,41.31 100.26,45.46 91.39,45.46 91.06,45.12 85.6,45.12 82.49,42.01 82.49,41.06 81.54,40.11 80.71,40.11 79.95,39.35 79.95,38.27 80.27,37.95 80.27,36.74 78.97,35.45 78.97,34.16 76.11,31.3 53.85,31.3 53.22,31.93 51.68,31.93 51.55,31.8 45.84,31.8 44.7,32.94 38.7,32.94 38.44,33.19 37.73,33.19 37.47,32.94 35.97,32.94 v3(35.64,33.28)
TX1_ENABLE: length 31.9
  TOP w0.254: U101.M6 v3(38.04,32.48)
  TOP w0.305: R115.1 51.25,41.44 P104.9
  L5_SIG w0.114: v3(38.04,32.48) 37.7,32.81 37.22,32.81 36.83,33.21 36.83,34.33 36.1,35.06 36.1,40.84 38.74,43.48 40.01,43.48 40.46,43.93 43.58,43.93 44.06,44.4 44.48,44.4 44.74,44.15 48.54,44.15 P104.9
  BOTTOM w0.203: R838.1 P104.9
TX2_ENABLE: length 24.7
  TOP w0.254: U101.M8 v3(38.04,34.88)
  TOP w0.305: P104.10 51.37,38.77 R114.1
  L5_SIG w0.114: v3(38.04,34.88) 38.04,35.2 37.63,35.61 37.63,35.84 37.63,35.84 37.63,39 38.67,40.04 40.09,40.04 41.68,41.63 48.51,41.63 P104.10
  BOTTOM w0.203: R841.1 P104.10
UNNAMED_2_ADRV90082_I138_RBIAS: length 2.5
  TOP w0.203: U101.C14 28.89,40.82 R101.1
UNNAMED_2_ADRV90082_I138_REFC_1: length 1.2
  TOP w0.203: U101.E7 v5(32.44,34.08)
  BOTTOM w0.203: C103.2 32.34,34.3 arc(32.37,34.18) v5(32.44,34.08)
UNNAMED_2_ADRV90082_I138_REFCLK: length 1.2
  TOP w0.203: U101.E8 v5(31.64,34.08)
  BOTTOM w0.203: C104.2 31.71,34.25 arc(31.69,34.16) v5(31.64,34.08)
UNNAMED_2_ADRV90082_I138_SER_10: length 126.7
  TOP w0.203: U101.P4 v3(39.56,30.95)
  L10_SIG w0.091: 147.32,52.58 arc(147.2,52.79) 146.96,52.87 146.95,52.87 arc(146.7,52.82) 146.48,52.68 146.42,52.61 arc(144.51,49.79) 143.84,46.44 143.84,37.96 arc(143.15,36.29) 141.48,35.6 141.47,35.6 arc(140.48,35.47) 139.6,35.02 arc(138.81,34.6) 137.92,34.46 133.35,34.46 arc(130.72,34.01) 128.49,32.55 arc(120.75,27.38) 111.63,25.57 63.41,25.57 arc(58.18,26.22) 53.25,28.11 arc(47.34,30.36) 41.05,31.13 39.98,31.13 arc(39.75,31.08) v3(39.56,30.95)
  BOTTOM w0.203: C108.2 147.32,52.58
UNNAMED_2_ADRV90082_I138_SER_11: length 119.9
  TOP w0.203: C109.2 v3(142.91,51.69)
  TOP w0.254: v3(38.84,32.48) U101.N6
  L10_SIG w0.091: v3(142.91,51.69) arc(142.81,51.37) 142.49,51.26 arc(141.92,51.07) 141.68,50.52 arc(141.7,50.27) 141.77,50.03 141.98,49.56 arc(142.11,49.17) 142.15,48.76 142.15,41.8 arc(141.69,39.88) 140.42,38.37 arc(138.78,37.51) 136.94,37.21 134,37.21 arc(128.49,36.29) 123.57,33.64 arc(117.94,30.61) 111.63,29.56 63.26,29.56 arc(57.67,29.89) 52.16,30.92 arc(47.07,31.88) 41.89,32.2 39,32.2 arc(38.84,32.29) v3(38.84,32.48)
UNNAMED_2_ADRV90082_I138_SER_12: length 119.9
  TOP w0.203: C110.2 v3(142.91,50.42)
  TOP w0.254: v3(38.84,31.68) U101.N5
  L10_SIG w0.091: v3(142.91,50.42) arc(142.82,50.81) 142.47,51.01 arc(142.09,50.88) 141.93,50.52 arc(141.95,50.32) 142.01,50.13 142.21,49.66 arc(142.36,49.22) 142.4,48.76 142.4,41.8 arc(141.92,39.76) 140.58,38.16 arc(138.86,37.27) 136.95,36.95 134,36.95 arc(128.57,36.05) 123.73,33.44 arc(118.02,30.37) 111.63,29.31 63.26,29.31 arc(57.63,29.64) 52.1,30.68 arc(47.03,31.63) 41.89,31.95 39.25,31.95 arc(39.01,31.87) v3(38.84,31.68)
UNNAMED_2_ADRV90082_I138_SER_13: length 127.4
  TOP w0.254: v3(38.84,30.88) U101.N4
  L10_SIG w0.091: 147.32,48.26 arc(147.17,48.1) 146.97,48.02 arc(145.49,47.17) 144.91,45.57 144.91,34 arc(144.36,32.67) 143.03,32.12 133.57,32.12 arc(130.67,31.63) 128.13,30.14 arc(120.44,25.55) 111.63,23.95 61.58,23.95 arc(55.3,24.87) 49.64,27.75 arc(45.52,29.87) 40.95,30.6 39.05,30.6 arc(38.88,30.69) v3(38.84,30.88)
  BOTTOM w0.203: C111.2 147.32,48.26
UNNAMED_2_ADRV90082_I138_SER_14: length 127.4
  TOP w0.254: v3(38.84,30.08) U101.N3
  L10_SIG w0.091: v3(38.84,30.08) arc(39.06,30.28) 39.36,30.35 40.95,30.35 arc(45.45,29.63) 49.49,27.55 arc(55.22,24.63) 61.58,23.7 111.63,23.7 arc(120.53,25.31) 128.3,29.94 arc(130.75,31.39) 133.56,31.86 143.03,31.86 arc(144.54,32.49) 145.16,34 145.16,45.57 arc(145.69,47.01) 147.02,47.77 arc(147.24,47.71) 147.32,47.5
  BOTTOM w0.203: C112.2 147.32,47.5
UNNAMED_2_ADRV90082_I138_SERD_1: length 114.3
  TOP w0.203: v3(38.84,38.88) U101.N13
  L5_SIG w0.091: 147.32,33.02 arc(147.13,32.82) 146.87,32.75 146.49,32.75 arc(145.78,32.59) 145.2,32.14 144.77,31.6 142.97,29.36 arc(140.84,27.67) 138.19,27.06 134.18,27.06 arc(132.37,27.23) 130.62,27.72 arc(127.2,29.26) 123.95,31.11 arc(117.28,34.13) 110.04,35.17 55.54,35.17 arc(51.44,35.64) 47.56,37.05 arc(44.29,38.22) 40.83,38.6 39.26,38.6 arc(39.01,38.68) v3(38.84,38.88)
  BOTTOM w0.203: C113.2 147.32,33.02
UNNAMED_2_ADRV90082_I138_SERD_2: length 115.5
  TOP w0.203: v3(38.84,36.48) U101.N10
  L5_SIG w0.091: 147.32,22.1 arc(147.19,22.28) 146.98,22.35 146.51,22.35 arc(145.9,22.26) 145.37,21.94 arc(144.56,21.18) 143.82,20.35 arc(142.74,19.49) 141.39,19.19 133.34,19.19 arc(131.1,19.39) 128.93,19.99 arc(124.24,22.06) 119.79,24.59 arc(115.12,26.71) 110.04,27.44 60.44,27.44 arc(50.8,29.48) 42.9,35.36 arc(41.52,36.38) 39.84,36.75 39.15,36.75 arc(38.94,36.67) v3(38.84,36.48)
  BOTTOM w0.203: C116.2 147.32,22.1
UNNAMED_2_ADRV90082_I138_SERD_3: length 115.5
  TOP w0.203: v3(38.84,37.28) U101.N11
  L5_SIG w0.091: 147.32,22.86 arc(147.19,22.68) 146.98,22.61 146.52,22.61 arc(145.82,22.49) 145.2,22.14 arc(144.38,21.36) 143.62,20.51 arc(142.63,19.72) 141.39,19.44 133.34,19.44 arc(131.14,19.64) 129.02,20.23 arc(124.36,22.29) 119.93,24.81 arc(115.19,26.96) 110.04,27.69 60.44,27.69 arc(50.91,29.71) 43.09,35.52 arc(41.62,36.62) 39.84,37 39.15,37 arc(38.94,37.08) v3(38.84,37.28)
  BOTTOM w0.203: C115.2 147.32,22.86
UNNAMED_2_ADRV90082_I138_SERD_4: length 117.1
  TOP w0.203: v3(39.64,39.68) U101.P14 ; C117.2 v3(142.91,59.31)
  L10_SIG w0.091: v3(142.91,59.31) arc(142.75,58.95) 142.39,58.8 140.4,58.8 arc(138.83,58.52) 137.5,57.65 arc(136.05,55.54) 135.29,53.1 arc(134.27,49.28) 132.42,45.78 arc(129.25,42.48) 125.16,40.4 arc(122.26,39.24) 119.56,37.66 arc(115.79,35.81) 111.63,35.17 55.41,35.17 arc(50.97,35.81) 46.85,37.59 arc(43.76,38.93) 40.42,39.39 40,39.39 arc(39.77,39.47) v3(39.64,39.68)
UNNAMED_2_ADRV90082_I138_SERD_5: length 117
  TOP w0.203: C118.2 v3(142.91,58.04) ; U101.P13 39.63,38.87 v3(39.63,38.94)
  L10_SIG w0.091: v3(39.63,38.94) arc(39.79,39.08) 40,39.13 40.42,39.13 arc(43.69,38.69) 46.72,37.38 arc(50.9,35.56) 55.41,34.92 111.63,34.92 arc(115.87,35.56) 119.71,37.45 arc(122.37,39.01) 125.23,40.16 arc(129.4,42.27) 132.63,45.64 arc(134.51,49.19) 135.54,53.06 arc(136.28,55.43) 137.69,57.47 arc(138.93,58.29) 140.39,58.55 142.38,58.55 arc(142.75,58.4) v3(142.91,58.04)
UNNAMED_2_ADRV90082_I138_SERD_6: length 113.1
  TOP w0.203: U101.P11 v3(39.62,37.35)
  L5_SIG w0.091: v3(39.62,37.35) arc(39.88,37.53) 40.19,37.59 40.55,37.59 arc(42.45,37.25) 44.12,36.27 arc(50.63,32.45) 58.08,31.18 110.04,31.18 arc(116.17,30.3) 121.8,27.75 arc(127.49,25.16) 133.67,24.24 141.44,24.24 arc(142.94,24.62) 144.08,25.67 144.49,26.29 arc(145.48,27.15) 146.77,27.37 arc(147.05,27.31) 147.32,27.18
  BOTTOM w0.203: C120.2 147.32,27.18
UNNAMED_2_ADRV90082_I138_SERD_7: length 113
  TOP w0.203: U101.P12 v3(39.58,38.01)
  L5_SIG w0.091: 147.32,27.94 arc(147.11,27.69) 146.79,27.62 arc(145.37,27.38) 144.28,26.43 143.87,25.81 arc(142.82,24.85) 141.44,24.5 133.67,24.5 arc(127.56,25.4) 121.94,27.96 arc(116.24,30.55) 110.04,31.43 58.08,31.43 arc(50.72,32.69) 44.28,36.46 arc(42.54,37.49) 40.55,37.85 40.19,37.85 arc(39.87,37.89) v3(39.58,38.01)
  BOTTOM w0.203: C119.2 147.32,27.94
UNNAMED_2_ADRV90082_I138_SERD_8: length 123.6
  TOP w0.203: U101.P6 v3(39.56,32.55)
  L10_SIG w0.091: v3(39.56,32.55) arc(39.77,32.75) 40.05,32.83 40.28,32.83 arc(45.36,32.88) 50.43,33.03 arc(52.96,33.09) 55.49,33.05 111.63,33.05 arc(116.12,33.69) 120.25,35.56 arc(126.72,38.5) 133.77,39.52 135.45,39.52 arc(136.81,40.08) 137.38,41.45 137.38,50.66 arc(137.44,50.98) 137.63,51.26 138.87,52.5 139.48,53.11 arc(139.84,53.36) 140.27,53.44 arc(140.89,53.57) 141.41,53.91 141.84,54.35 142.44,54.95 142.44,54.95 arc(142.87,55.46) 143.24,56.02 arc(143.25,56.03) 143.25,56.04 arc(144.73,57.42) 146.69,57.9 146.98,57.9 146.99,57.9 arc(147.2,57.84) 147.32,57.66
  BOTTOM w0.203: C106.2 147.32,57.66
UNNAMED_2_ADRV90082_I138_SERD_9: length 126.7
  TOP w0.203: U101.P5 v3(39.7,31.62)
  L10_SIG w0.091: v3(39.7,31.62) 39.8,31.53 arc(39.96,31.42) 40.15,31.38 41.05,31.38 arc(47.4,30.61) 53.37,28.33 arc(58.24,26.47) 63.41,25.82 111.63,25.82 arc(120.66,27.62) 128.31,32.73 arc(130.63,34.25) 133.36,34.71 137.92,34.71 arc(138.73,34.84) 139.45,35.22 arc(140.41,35.71) 141.48,35.85 arc(142.97,36.47) 143.59,37.96 143.59,46.44 arc(144.28,49.89) 146.24,52.79 146.3,52.85 arc(146.6,53.05) 146.95,53.12 arc(147.16,53.19) 147.32,53.34
  BOTTOM w0.203: C107.2 147.32,53.34
UNNAMED_2_ADRV90082_I138_SERDIN: length 114.3
  TOP w0.203: v3(38.84,38.08) U101.N12
  L5_SIG w0.091: v3(38.84,38.08) arc(39.01,38.27) 39.26,38.35 40.83,38.35 arc(44.23,37.97) 47.45,36.82 arc(51.38,35.4) 55.54,34.92 110.04,34.92 arc(117.21,33.89) 123.81,30.9 arc(127.09,29.03) 130.53,27.49 arc(132.32,26.98) 134.18,26.81 138.19,26.81 arc(140.95,27.44) 143.17,29.2 144.96,31.44 145.4,31.98 arc(145.89,32.36) 146.49,32.49 146.86,32.49 147,32.49 arc(147.2,32.43) 147.32,32.26
  BOTTOM w0.203: C114.2 147.32,32.26
UNNAMED_2_ADRV90082_I138_SERDOU: length 123.6
  TOP w0.203: U101.P7 v3(39.56,33.35)
  L10_SIG w0.091: v3(39.56,33.35) arc(39.77,33.15) 40.05,33.08 40.28,33.08 arc(45.35,33.13) 50.42,33.29 arc(52.96,33.34) 55.5,33.3 111.63,33.3 arc(116.05,33.93) 120.11,35.77 arc(126.65,38.75) 133.77,39.77 135.45,39.77 arc(136.63,40.26) 137.12,41.45 137.12,50.66 arc(137.21,51.08) 137.45,51.44 139.3,53.29 arc(139.75,53.59) 140.27,53.7 arc(140.79,53.8) 141.23,54.09 142.2,55.07 arc(142.65,55.58) 143.02,56.15 arc(143.03,56.16) 143.04,56.17 arc(144.61,57.64) 146.7,58.15 146.98,58.15 arc(147.19,58.23) 147.32,58.42
  BOTTOM w0.203: C105.2 147.32,58.42
UNNAMED_2_ADRV90082_I138_VDDA1P: length 1.7
  TOP w0.203: v5(30.08,36.48) 30.84,36.48
  TOP w0.254: 30.84,36.48 U101.D10
  BOTTOM w0.305: v5(30.08,36.48) 30.08,36.82 30.1,36.84 30.1,36.87
  BOTTOM w0.394: C137.1 30.1,36.87
UNNAMED_2_ADRV90082_I138_VDDA_1: length 1.2
  TOP w0.254: v1(38.04,28.48) U101.M1
  BOTTOM w0.305: 37.96,28.55 v1(38.04,28.48)
  BOTTOM w0.394: 37.96,28.55 37.66,28.86 C101.1
UNNAMED_2_ADRV90082_I138_VDDA_2: length 0.9
  TOP w0.254: v1(30.04,33.28) U101.C7
  BOTTOM w0.203: v1(30.04,33.28) 30.06,33.25 C102.1
UNNAMED_2_ICS25FL208K_I27_HOLDN: length 2.2
  BOTTOM w0.203: R119.2 44.33,60.05
UNNAMED_2_ICS25FL208K_I27_WPN: length 2.3
  BOTTOM w0.203: R120.2 U102.3
UNNAMED_3_CAP_I206_N1: length 17.2
  BOTTOM w0.305: 16.82,15.89 16.69,15.74
  BOTTOM w0.394: 16.69,15.74 16.55,15.56 C222.1 15.89,14.81 arc(11.35,11.76) 5.98,10.68 arc(3.62,10.67) J204.1
UNNAMED_3_CAP_I230_N1: length 18.3
  BOTTOM w0.305: R216.1 16.79,52.2
  BOTTOM w0.394: 16.79,52.2 C215.1 arc(12.91,56.99) 7.95,58.42 J203.1
UNNAMED_3_CAP_I248_N1: length 2.6
  BOTTOM w0.356: C244.1 C245.2
  BOTTOM w0.394: C245.2 19.83,49.22 20.4,48.23 T205.2
UNNAMED_3_CAP_I252_N1: length 2.6
  BOTTOM w0.356: C246.1 17.64,19.42
  BOTTOM w0.508: T207.2 C247.2 17.65,19.42 17.64,19.42
UNNAMED_3_CAP_I258_N2: length 0.7
  BOTTOM w0.305: C251.2 19.19,18.72
  BOTTOM w0.394: 19.19,18.72 19.51,19.22
UNNAMED_3_CAP_I259_N2: length 0.7
  BOTTOM w0.305: C250.2 18.42,48.73
  BOTTOM w0.394: 18.42,48.73 18.73,48.23
UNNAMED_4_CAP_I166_N1: length 4.6
  BOTTOM w0.203: 96.02,50.42 95.2,50.42 C405.1 ; 96.02,50.42 R405.2 ; 96.02,50.42 96.83,50.42 R404.2 97.46,49.79 98.01,49.79 98.48,49.32 T401.3
UNNAMED_4_CAP_I168_N1: length 6.4
  BOTTOM w0.394: J401.1 107.27,47.87 R401.2 C401.1
UNNAMED_4_CAP_I168_N2: length 1.6
  BOTTOM w0.394: C401.2 T401.4
UNNAMED_4_CAP_I177_N1: length 4.6
  BOTTOM w0.203: R405.1 96.02,50.77 ; 96.02,50.77 95.2,50.77 C403.1 ; 96.02,50.77 96.85,50.77 R403.1 97.49,51.42 97.99,51.42 98.43,51.86 T401.1
UNNAMED_4_CAP_I184_N1: length 61.4
  BOTTOM w0.203: C409.1 88.76,49.67 88.43,49.34 88.43,48.61 89.65,47.39 96.93,47.39 100.87,43.46 113.65,43.46 115.6,45.41 115.6,50.57 113,53.17 106.9,53.17 103.54,56.53 103.54,59.96 105.03,61.44 107.45,61.44 108.27,60.61 R413.1 R417.2
UNNAMED_4_CAP_I192_N2: length 1.2
  BOTTOM w0.203: R439.1 91.56,53.74 C415.2
UNNAMED_4_CAP_I292_N2: length 2.5
  TOP w0.203: J405.1 105.98,61.89 105.78,62.09 105.78,63.08 C411.2
UNNAMED_4_CAP_I294_N2: length 2.5
  TOP w0.203: J404.1 105.22,61.89 105.42,62.09 105.42,63.08 C410.2
UNNAMED_4_CAP_I303_N2: length 1.7
  TOP w0.203: J407.1 79.19,64.18 C413.2
UNNAMED_4_CAP_I304_N2: length 1.7
  TOP w0.203: J406.1 78.17,64.18 C412.2
UNNAMED_4_CAP_I329_N1: length 3.2
  TOP w0.203: R449.2 97.36,57 R450.2 95.84,56.44 v2(95.84,55.87)
  BOTTOM w0.203: C420.1 v2(95.84,55.87)
UNNAMED_4_CAP_I330_N1: length 3.3
  TOP w0.203: R448.2 97.36,57.63 R450.1 95.84,58.19 v2(95.84,58.83)
  BOTTOM w0.203: C419.1 v2(95.84,58.83)
UNNAMED_4_CMOSNC7WV125K8X_I27_1: length 3.6
  TOP w0.203: 115.71,48.39 U402.5
  TOP w0.254: 115.71,48.39 115.71,48.06 115.33,47.67 R454.1
UNNAMED_4_CMOSNC7WV125K8X_I279_: length 1.4
  TOP w0.254: R453.1 116.72,52.2 116.71,52.19 U402.2
UNNAMED_4_CNBNC3P_I148_CNTR: length 10.5
  TOP w0.203: J411.1 74.48,56.55 74.33,56.7 74.33,58.88 75.16,59.71 78.81,59.71 79.02,59.51 79.02,58.41 v2(79.05,58.41)
  BOTTOM w0.203: R438.2 v2(79.05,58.41)
UNNAMED_4_CNBNC3P_I248_CNTR: length 10.5
  TOP w0.203: v2(79.02,61.37) 79.02,60.27 78.81,60.07 75.01,60.07 73.98,59.03 73.98,56.82 73.71,56.55 J410.1
  BOTTOM w0.203: R437.2 v2(79.02,61.37)
UNNAMED_4_CNBNC3P_I306_CNTR: length 1.7
  TOP w0.203: J409.1 68.39,64.18 R430.2
UNNAMED_4_CNBNC3P_I308_CNTR: length 1.7
  TOP w0.203: R429.2 69.41,64.18 J408.1
UNNAMED_4_CNBNC3P_I318_CNTR: length 11.7
  TOP w0.203: v2(99.56,61.88) 99.56,60.75 99.76,60.54 100.53,60.54 101.88,59.2 104.29,59.2 105.96,57.53 105.96,56.51 106.68,55.79 J403.1
  BOTTOM w0.203: R422.1 v2(99.56,61.88)
UNNAMED_4_CNBNC3P_I321_CNTR: length 11.7
  TOP w0.203: J402.1 105.29,55.79 105.61,56.11 105.61,57.38 104.14,58.84 101.73,58.84 100.38,60.19 99.76,60.19 99.56,59.98 99.56,58.85 v2(99.52,58.85)
  BOTTOM w0.203: R421.1 v2(99.52,58.85)
UNNAMED_4_CNBNC3P_I324_CNTR: length 9.5
  TOP w0.203: J412.1 100.97,50.97 100.52,50.97 100.32,51.17 100.32,57.41 99.91,57.82 R448.1
UNNAMED_4_CNBNC3P_I325_CNTR: length 9.5
  TOP w0.203: J413.1 99.57,50.59 99.96,50.98 99.96,57.27 99.76,57.47 99.34,57.47 99.19,57.32 99.19,56.94 99.05,56.79 98.56,56.79 R449.1
UNNAMED_4_CNTP1P_I73_N1: length 11.5
  TOP w0.203: R444.2 99.71,67.72 TP403.1
  BOTTOM w0.203: U405.1 101.31,66.12 TP403.1
UNNAMED_4_CNTP1P_I74_N1: length 9.5
  TOP w0.203: TP402.1 101.98,66.21 98.3,66.21 97.79,66.71 R445.2
  BOTTOM w0.305: TP402.1 106.37,67.48 U405.3
UNNAMED_4_DIOLED_I333_P: length 1.5
  TOP w0.203: R446.2 DS401.A
UNNAMED_4_DIOLED_I334_P: length 1.5
  TOP w0.203: R447.2 DS402.A
UNNAMED_4_NC7WZ17P6X_I76_Y1: length 2.8
  TOP w0.203: R446.1 v2(109.74,67.22)
  BOTTOM w0.203: v2(109.74,67.22) 109.74,66.98 108.88,66.12 U405.6
UNNAMED_4_NC7WZ17P6X_I76_Y2: length 1.9
  TOP w0.203: R447.1 v2(109.1,68.37)
  BOTTOM w0.203: U405.4 109.1,68.19 v2(109.1,68.37)
UNNAMED_4_RES_I165_N2: length 61.4
  BOTTOM w0.203: R410.2 R412.2 107.96,59.13 107.96,57.98 107.62,57.65 106.67,57.65 105.64,58.67 104.34,58.67 103.9,58.23 103.9,56.68 107.05,53.53 113.14,53.53 115.96,50.71 115.96,45.26 113.8,43.1 100.72,43.1 96.78,47.04 89.5,47.04 88.07,48.46 88.07,49.34 87.74,49.67 R411.1
UNNAMED_4_RES_I268_N2: length 1.6
  BOTTOM w0.394: T401.5 R402.2
UNNAMED_5_CNTP1P_I268_N1: length 2
  BOTTOM w0.508: 23.62,63.03 TP604.1 22.61,64.05
UNNAMED_5_RES_I164_N2: length 3.3
  BOTTOM w0.762: 7.62,46.54 7.64,46.52 7.75,46.52 R613.1 ; 6.99,47.66 R608.2
  BOTTOM w1.016: 7.62,47.41 7.24,47.41 6.99,47.66 ; 7.62,47.41 TP610.1 ; 7.62,47.41 7.62,46.54
UNNAMED_5_RES_I174_N2: length 5.8
  BOTTOM w0.394: R604.2 TP606.1 R612.1
UNNAMED_7_CAP_I11_N2: length 1.5
  TOP w0.203: C802.2 v1(139.12,55.52)
  BOTTOM w0.203: v1(139.12,55.52) 139.74,54.9 P801.D5
UNNAMED_7_CAP_I12_N2: length 1.5
  TOP w0.203: C801.2 140.39,55.5 v1(140.36,55.47)
  BOTTOM w0.203: v1(140.36,55.47) 139.74,56.1 P801.D4
UNNAMED_7_CAP_I157_N2: length 25.5
  TOP w0.203: v1(142.91,35.18) 142.52,35.58 142.52,37.27 143.8,38.56 143.8,53.25 143.21,53.84 140.55,53.84 140.05,54.34 140.05,54.65 140.29,54.89 140.46,54.89 140.56,54.99 140.56,54.99 140.84,55.27 140.84,55.28 C803.2
  BOTTOM w0.203: v1(142.91,35.18) P801.B20
UNNAMED_7_CAP_I158_N2: length 25.5
  TOP w0.203: C804.2 139.23,54.71 139.3,54.71 139.59,54.43 139.59,54.35 139.67,54.27 139.67,54.22 140.4,53.49 143.07,53.49 143.45,53.11 143.45,38.71 142.16,37.42 142.16,35.63 v1(141.67,35.14)
  BOTTOM w0.203: v1(141.67,35.14) 142.27,34.54 P801.B21
UNNAMED_7_CN400PAK_I2_N8: length 1.6
  TOP w0.203: v1(140.39,51.71) 140.27,51.6 R834.2
  BOTTOM w0.203: v1(140.39,51.71) 140.39,51.7 P801.D8
UNNAMED_7_CN400PAK_I2_N9: length 1.2
  TOP w0.203: R835.2 139.13,49.18 v1(139.1,49.15)
  BOTTOM w0.203: P801.D9 v1(139.1,49.15)
UNNAMED_7_CN400PAK_I2_N14: length 1.5
  TOP w0.305: v1(140.37,42.8) 140.38,42.79 R846.2
  BOTTOM w0.203: P801.D14 v1(140.37,42.8)
UNNAMED_7_CN400PAK_I2_N15: length 1.5
  TOP w0.305: v1(140.37,41.53) 140.38,41.52 R847.2
  BOTTOM w0.203: P801.D15 v1(140.37,41.53)
UNNAMED_7_CN400PAK_I2_N17: length 92.4
  L8_SIG w0.114: v1(139.1,40.26) 137.34,42.02 108.76,42.02 104.19,46.59 91.06,46.59 89.67,45.19 88.02,45.19 87.84,45.38 78.11,45.38 77.41,44.68 72.52,44.68 70.69,42.85 v2(52.61,42.85)
  BOTTOM w0.203: P801.D17 v1(139.1,40.26) ; R838.2 v2(52.61,42.85)
UNNAMED_7_CN400PAK_I2_N18: length 90.2
  L8_SIG w0.114: v2(63.18,41.95) 69.03,41.95 69.41,42.33 71,42.33 72.52,43.85 77.6,43.85 78.49,44.74 87.51,44.74 87.63,44.62 89.85,44.62 90.74,45.51 103.39,45.51 107.96,40.94 123.26,40.94 123.27,40.95 123.7,40.95 123.71,40.94 136.28,40.94 138.23,38.99 v1(139.1,38.99)
  BOTTOM w0.203: R839.2 62.28,42.85 v2(63.18,41.95) ; P801.D18 v1(139.1,38.99)
UNNAMED_7_CN400PAK_I27_N10: length 1.2
  TOP w0.203: v1(140.37,47.88) 140.4,47.91 R816.2
  BOTTOM w0.203: P801.C10 v1(140.37,47.88)
UNNAMED_7_CN400PAK_I27_N11: length 1.2
  TOP w0.203: R817.2 141.61,47.92 v1(141.64,47.88)
  BOTTOM w0.203: P801.C11 v1(141.64,47.88)
UNNAMED_7_CN400PAK_I27_N18: length 97.4
  L8_SIG w0.114: v1(141.64,37.72) 137.59,37.72 136.84,38.47 136.4,38.47 135.76,39.11 135.76,39.18 135.49,39.45 106.91,39.45 101.93,44.43 90.81,44.43 90.25,43.86 80.91,43.86 80.27,43.22 72.77,43.22 70.42,40.87 63.63,40.87 62.8,40.04 60.84,40.04 60.07,39.28 60.07,38.27 58.61,36.81 v2(53.28,36.81)
  BOTTOM w0.203: v2(53.28,36.81) 52.5,36.81 R841.2 ; v1(141.64,37.72) P801.C18
UNNAMED_7_CN400PAK_I27_N19: length 95.3
  L8_SIG w0.114: v1(141.64,36.45) 141.07,37.02 130.93,37.02 130.09,37.86 128.06,37.86 127.57,37.38 126.25,37.38 125.49,38.15 105.66,38.15 100.08,43.73 91,43.73 90.53,43.26 85.45,43.26 84.97,42.78 78.36,42.78 77.41,41.82 77.41,40.93 76.52,40.04 v2(64.07,40.04)
  BOTTOM w0.203: v2(64.07,40.04) 55.96,40.04 55.23,39.32 55.23,38.11 R842.2 ; v1(141.64,36.45) P801.C19
UNNAMED_7_CN400PAK_I27_N22: length 1.3
  TOP w0.203: v1(141.64,32.64) 141.67,32.67 R843.2
  BOTTOM w0.394: v1(141.64,32.64) P801.C22
UNNAMED_7_CN400PAK_I27_N23: length 1.4
  TOP w0.203: R844.2 140.35,32.62 v1(140.37,32.64)
  BOTTOM w0.394: P801.C23 v1(140.37,32.64)
UNNAMED_7_CN400PAK_I52_N2: length 1.5
  TOP w0.305: R801.2 133.69,58.37 v1(134.02,58.04)
  BOTTOM w0.203: v1(134.02,58.04) P801.H2
UNNAMED_7_CN400PAK_I52_N7: length 6.3
  TOP w0.203: v1(134.02,52.97) 134.02,52.69 133.82,52.49 133.42,52.49 133.18,52.73 132,52.73 131.8,52.53 130.31,52.53 130.02,52.52 129.7,52.84 R802.2
  BOTTOM w0.203: v1(134.02,52.97) 134.02,52.96 P801.H7
UNNAMED_7_CN400PAK_I52_N8: length 6.3
  TOP w0.203: v1(134.02,51.65) 134.02,51.93 133.82,52.13 133.27,52.13 133.03,52.37 132.15,52.37 131.95,52.17 130.31,52.17 130.02,52.17 129.71,51.85 R803.2
  BOTTOM w0.203: v1(134.02,51.65) 134.06,51.65 P801.H8
UNNAMED_7_CN400PAK_I52_N10: length 1.8
  TOP w0.394: v1(135.29,47.88) 134.67,48.5 R804.2
  BOTTOM w0.203: P801.H10 v1(135.29,47.88)
UNNAMED_7_CN400PAK_I52_N11: length 1.8
  TOP w0.394: v1(135.29,46.61) 134.7,47.21 R805.2
  BOTTOM w0.203: v1(135.29,46.61) P801.H11
UNNAMED_7_CN400PAK_I52_N13: length 1.5
  TOP w0.394: R806.2 v1(134.02,44.07)
  BOTTOM w0.203: v1(134.02,44.07) P801.H13
UNNAMED_7_CN400PAK_I52_N14: length 1.5
  TOP w0.394: R807.2 v1(135.29,44.07)
  BOTTOM w0.203: P801.H14 v1(135.29,44.07)
UNNAMED_7_CN400PAK_I52_N16: length 1.7
  TOP w0.203: R836.2 134.02,41.15 v1(134.02,41.53)
  BOTTOM w0.203: P801.H16 v1(134.02,41.53)
UNNAMED_7_CN400PAK_I52_N17: length 95.2
  L5_SIG w0.114: v1(134.02,40.26) 134.02,40.27 134.62,40.87 136.53,40.87 136.72,41.07 136.76,41.07 137.03,41.34 137.03,41.37 137.16,41.51 137.16,44.17 135.19,46.15 135.1,46.15 134.83,46.42 134.83,46.51 132.77,48.56 130.44,48.56 129.36,49.64 127.12,49.64 124.65,52.11 117.29,52.11 116.4,53 106.3,53 104.4,51.09 102.87,51.09 98.78,47.01 87.98,47.01 87.82,47.16 78.43,47.16 75.88,44.62 74.49,44.62 68.39,38.52 v2(64.07,38.52)
  BOTTOM w0.203: v1(134.02,40.26) P801.H17
  BOTTOM w0.254: 59.57,37.37 62.92,37.37 v2(64.07,38.52)
UNNAMED_7_CN400PAK_I52_N19: length 1.3
  TOP w0.203: R808.2 134,37.7 v1(134.02,37.72)
  BOTTOM w0.394: v1(134.02,37.72) P801.H19
UNNAMED_7_CN400PAK_I52_N20: length 1.3
  TOP w0.203: R809.2 134,36.43 v1(134.02,36.45)
  BOTTOM w0.394: v1(134.02,36.45) P801.H20
UNNAMED_7_CN400PAK_I52_N22: length 1.5
  TOP w0.203: v1(135.29,32.64) 134.97,32.96 R810.2
  BOTTOM w0.203: v1(135.29,32.64) P801.H22
UNNAMED_7_CN400PAK_I52_N23: length 1.5
  TOP w0.203: v1(135.29,31.37) 134.97,31.69 R811.2
  BOTTOM w0.203: v1(135.29,31.37) P801.H23
UNNAMED_7_CN400PAK_I52_N25: length 1.2
  TOP w0.203: v1(134.02,30.1) 134,30.08 R812.2
  BOTTOM w0.394: v1(134.02,30.1) P801.H25
UNNAMED_7_CN400PAK_I52_N26: length 61.9
  TOP w0.203: v3(99.57,41.89) 95.38,46.08 91.64,46.08 89.92,44.36 R813.2
  L7_SIG w0.114: v3(99.57,41.89) 99.57,41.86 102.13,39.29 129.17,39.29 129.48,39.6 135.34,39.6 135.83,39.11 135.83,31.25 135.49,30.91 135.26,30.91 134.56,30.2 134.56,29.76 134.02,29.22 v1(134.02,28.83)
  BOTTOM w0.394: v1(134.02,28.83) P801.H26
UNNAMED_7_CN400PAK_I52_N28: length 1.6
  TOP w0.203: v1(135.29,25.02) 135,24.73 R814.2
  BOTTOM w0.203: P801.H28 v1(135.29,25.02)
UNNAMED_7_CN400PAK_I52_N29: length 1.7
  TOP w0.203: v1(135.29,23.75) 135,23.46 R815.2
  BOTTOM w0.203: P801.H29 v1(135.29,23.75)
UNNAMED_7_CN400PAK_I55_N6: length 1.3
  TOP w0.203: R818.2 136.46,52.81 v1(136.59,52.94)
  BOTTOM w0.203: P801.G6 136.59,52.94 v1(136.59,52.94)
UNNAMED_7_CN400PAK_I55_N7: length 1.3
  TOP w0.203: v1(136.59,51.67) 136.46,51.79 R819.2
  BOTTOM w0.203: v1(136.59,51.67) 136.59,51.67 P801.G7
UNNAMED_7_CN400PAK_I55_N9: length 1.3
  TOP w0.203: v1(136.56,49.15) 136.59,49.13 R820.2
  BOTTOM w0.203: P801.G9 v1(136.56,49.15)
UNNAMED_7_CN400PAK_I55_N10: length 1.3
  TOP w0.203: R821.2 136.59,47.86 v1(136.56,47.88)
  BOTTOM w0.203: P801.G10 v1(136.56,47.88)
UNNAMED_7_CN400PAK_I55_N12: length 1.6
  TOP w0.203: v1(135.29,45.34) 135.43,45.48 R845.2
  BOTTOM w0.203: P801.G12 v1(135.29,45.34)
UNNAMED_7_CN400PAK_I55_N15: length 1.2
  TOP w0.203: v1(136.56,41.53) 136.46,41.63 R830.2
  BOTTOM w0.203: P801.G15 v1(136.56,41.53)
UNNAMED_7_CN400PAK_I55_N16: length 1.2
  TOP w0.203: R831.2 135.32,41.56 v1(135.29,41.53)
  BOTTOM w0.203: P801.G16 v1(135.29,41.53)
UNNAMED_7_CN400PAK_I55_N18: length 1.3
  TOP w0.203: v1(136.56,37.72) 136.31,37.98 R822.2
  BOTTOM w0.394: v1(136.56,37.72) P801.G18
UNNAMED_7_CN400PAK_I55_N19: length 1.3
  TOP w0.203: R823.2 135.27,37.7 v1(135.29,37.72)
  BOTTOM w0.394: P801.G19 v1(135.29,37.72)
UNNAMED_7_CN400PAK_I55_N21: length 1.2
  TOP w0.203: v1(135.29,33.91) 135.26,33.95 R824.2
  BOTTOM w0.203: P801.G21 v1(135.29,33.91)
UNNAMED_7_CN400PAK_I55_N22: length 1.2
  TOP w0.203: v1(136.56,33.91) 136.53,33.95 R825.2
  BOTTOM w0.203: P801.G22 v1(136.56,33.91)
UNNAMED_7_CN400PAK_I55_N24: length 1.6
  TOP w0.203: v1(136.56,31.37) 136.12,30.92 R826.2
  BOTTOM w0.203: P801.G24 v1(136.56,31.37)
UNNAMED_7_CN400PAK_I55_N25: length 1.9
  TOP w0.203: R827.2 135.98,29.22 136.09,29.11 136.28,29.11 v1(136.56,28.83)
  BOTTOM w0.394: v1(136.56,28.83) P801.G25
UNNAMED_7_CN400PAK_I55_N27: length 1.4
  TOP w0.203: R828.2 134.92,27.19 v1(135.29,27.56)
  BOTTOM w0.203: P801.G27 v1(135.29,27.56)
UNNAMED_7_CN400PAK_I55_N28: length 1.4
  TOP w0.203: R829.2 134.97,25.97 v1(135.29,26.29)
  BOTTOM w0.203: P801.G28 v1(135.29,26.29)
UNNAMED_7_CN400PAK_I67_N1: length 4.5
  TOP w0.394: v1(137.83,60.58) 136.56,60.58 135.12,62.02 R848.2
  BOTTOM w0.394: P801.F1 v1(137.83,60.58)
UNNAMED_9_AD7291_I112_DCAP: length 2.7
  TOP w0.305: U703.8 45.73,10.59 45.35,10.21 44.46,10.21 44.21,9.96
  TOP w0.394: 44.21,9.96 C706.1
UNNAMED_9_AD7291_I112_VIN0: length 5.3
  TOP w0.305: U703.18 51.2,10.59 51.58,10.21 52.09,10.21 53.48,8.81 R715.1 R714.1
UNNAMED_9_AD7291_I112_VIN1: length 4.6
  TOP w0.305: 53.62,11.04 53.58,11.09 U703.19 ; 53.62,11.04 R717.2 ; 53.62,11.04 R716.2
UNNAMED_9_AD7291_I112_VIN2: length 5.3
  TOP w0.305: U703.20 50.79,11.59 51.19,11.99 52.09,11.99 53.48,13.39 R718.2 R719.2
UNNAMED_9_AD7291_I112_VIN3: length 4.7
  TOP w0.305: R721.2 R720.2 51.56,15.22 49.52,13.18 U703.1
UNNAMED_9_AD7291_I112_VIN4: length 4
  TOP w0.254: U703.2 49.02,12.62 49.02,13.68 49.47,14.14 R722.2 R723.2
UNNAMED_9_AD7291_I112_VIN5: length 3.9
  TOP w0.305: R724.2 R725.2 48.4,14.44 48.51,14.34 48.51,12.62 U703.3
UNNAMED_9_AD7291_I112_VIN7: length 4.3
  TOP w0.305: U703.5 47.52,13.53 46.29,14.76 R727.2 R726.2
UNNAMED_9_AD7291_I112_VREF: length 2.3
  TOP w0.305: C705.1 45.01,11.22 45.6,11.22 45.74,11.09 U703.7
UNNAMED_9_CN20PV2_I59_N1: length 35.2
  TOP w0.203: R702.1 v3(85.72,44.3) ; P701.2 60.2,58.97 60.71,58.46 61.85,58.46 65.03,55.28 68.07,55.28 v3(68.84,54.52)
  L10_SIG w0.114: v3(68.84,54.52) 68.84,54.4 70.87,52.36 70.87,48.93 72.51,47.29 77.73,47.29 80.72,44.3 v3(85.72,44.3)
UNNAMED_9_CN20PV2_I59_N2: length 33.7
  TOP w0.203: R704.1 60.64,35.28 61.22,35.85 61.22,36.68 60.2,37.7 v3(60.2,45.51)
  TOP w0.394: P701.4 v2(58.93,58.07)
  L10_SIG w0.114: v3(60.2,45.51) 60.2,45.51 59.06,46.65 59.05,46.65 57.66,48.05 57.66,52.75 54.61,55.8 54.61,57.89 55.82,59.09 57.9,59.09 v2(58.93,58.07)
UNNAMED_9_CN20PV2_I59_N3: length 45.7
  TOP w0.203: R705.1 88.82,45.02 v3(88.2,45.63)
  TOP w0.394: P701.6 v2(57.66,58.07)
  L10_SIG w0.114: v2(57.66,58.07) 57.27,58.46 56.14,58.46 55.76,58.08 55.76,57.06 56.9,55.92 61.47,55.92 62.23,55.16 69.09,55.16 71.5,52.74 71.5,49.57 73.15,47.92 79.01,47.92 81.3,45.63 v3(88.2,45.63)
UNNAMED_9_CN20PV2_I59_N4: length 51
  TOP w0.203: v2(87.51,46.65) 87.51,36.76 R706.1
  TOP w0.394: P701.8 v2(56.39,57.89)
  L10_SIG w0.114: v2(56.39,57.89) 56.77,57.51 57.66,57.51 58.52,56.65 59.58,56.65 62.03,59.09 65.79,59.09 68.26,56.62 73.98,56.62 76.58,54.01 78.88,54.01 79.89,53.01 79.89,51.92 81,50.81 81.62,50.81 82.27,50.16 82.27,49.54 85.16,46.65 v2(87.51,46.65)
UNNAMED_9_CN20PV2_I59_N8: length 61.3
  TOP w0.203: v2(85.99,51.86) 85.99,49.01 84.95,47.97 84.95,37.27 86.87,35.35 88.15,35.35 88.72,35.92 R707.1
  TOP w0.394: P701.16 v2(51.31,58.07)
  L10_SIG w0.114: v2(51.31,58.07) 53.99,60.75 70.23,60.75 70.36,60.87 71.76,60.87 75.44,57.19 78.49,57.19 82.29,53.39 84.46,53.39 v2(85.99,51.86)
UNNAMED_9_CN20PV2_I60_N6: length 4.1
  TOP w0.394: TP702.1 53.85,65.93 P701.11
UNNAMED_9_CN20PV2_I60_N7: length 3.7
  TOP w0.394: TP701.1 52.58,67 P701.13
UNNAMED_9_CN20PV2_I60_N9: length 2.4
  TOP w0.394: R701.2 P701.17
UNNAMED_10_CAP_I51_N1: length 8.5
  TOP w0.127: 35.49,56.85 35.5,56.86 C314.1
  TOP w0.394: J303.1 35.49,64.12 35.49,56.85 R309.2
UNNAMED_10_CAP_I60_N1: length 9.6
  TOP w0.203: 34.18,11.3 arc(34.18,11.24) C322.1
  TOP w0.394: 34.18,11.3 R312.2 C322.1 arc(34.23,10.05) 34.42,8.93 arc(34.61,7.86) 34.67,6.77 J304.1
UNNAMED_10_CAP_I118_N1: length 17.2
  BOTTOM w0.394: J301.1 C301.1 R302.1
UNNAMED_10_CAP_I121_N1: length 3.6
  BOTTOM w0.203: C303.1 21.19,34.55 T301.1
  BOTTOM w0.394: 20,34.54 R302.2 ; 20,34.54 C303.1 ; 20,34.54 21.19,34.55
UNNAMED_10_CAP_I142_N1: length 0.8
  TOP w0.133: 33.47,43.47 L323.2
  TOP w0.279: C323.1 33.47,43.47
UNNAMED_10_CAP_I145_N1: length 0.8
  TOP w0.133: 36.21,43.47 L325.2
  TOP w0.279: C325.1 36.21,43.47
UNNAMED_10_CAP_I148_N1: length 0.8
  TOP w0.133: 36.21,24.68 L327.2
  TOP w0.279: C327.1 36.21,24.68
UNNAMED_10_CAP_I152_N1: length 0.8
  TOP w0.133: 33.47,24.68 L329.2
  TOP w0.279: C329.1 33.47,24.68
UNNAMED_10_CAP_I156_N2: length 2
  TOP w0.127: 34.18,14.89 C336.2
  TOP w0.394: R312.1 C320.1 34.18,14.89
UNNAMED_10_CAP_I157_N2: length 2
  TOP w0.127: 35.5,53.26 C337.2
  TOP w0.394: 35.5,53.26 C312.1 R309.1
UNNAMED_10_CAP_I181_N2: length 4.6
  TOP w0.508: C345.2 C344.2 33.59,53.37 C347.2 33.59,53.37 C346.2 33.59,52.16 34.23,51.53 T302.2
UNNAMED_10_CAP_I188_N2: length 4.7
  TOP w0.305: C351.2 36.08,13.05 36.08,13.61 ; C350.2 36.13,13.96 36.08,14.01
  TOP w0.508: 36.08,13.61 36.08,14.78 ; T303.2 35.45,16.62 36.08,15.99 C348.2 36.08,14.78 ; C349.2 36.08,14.78
UNNAMED_10_CNBNC3P_I129_CNTR: length 3.9
  BOTTOM w0.394: R304.1 24.07,35.03 24.7,35.66 24.7,36.3 23.24,37.76 J305.1
UNNAMED_10_CNBNC3P_I130_CNTR: length 3.4
  BOTTOM w0.394: J306.1 24.13,31.03 24.13,32.68 R305.1
UNNAMED_11_ADP125_I130_ADJ: length 3.1
  TOP w0.254: R940.2 R939.1 50.34,2.64 U902.3
UNNAMED_11_ADP5054_I29_BST1: length 2
  TOP w0.394: C913.1 84.23,13.91 83.46,13.91 v2(83.45,13.92)
  BOTTOM w0.203: U901.32 v2(83.45,13.92)
UNNAMED_11_ADP5054_I29_BST2: length 2
  TOP w0.394: v2(83.56,11.92) 83.58,11.9 C915.2
  BOTTOM w0.254: U901.28 v2(83.56,11.92)
UNNAMED_11_ADP5054_I29_BST3: length 2
  TOP w0.394: C917.1 93.44,15.92 v2(92.4,15.92)
  BOTTOM w0.254: U901.1 v2(92.4,15.92)
UNNAMED_11_ADP5054_I29_BST4: length 1.7
  BOTTOM w0.254: C919.1 92.86,10.42 U901.12
